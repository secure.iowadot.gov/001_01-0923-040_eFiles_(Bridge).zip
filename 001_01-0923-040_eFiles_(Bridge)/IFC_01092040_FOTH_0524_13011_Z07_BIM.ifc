Properties of the parts of a building model (IFC4X3_ADD2), part 6 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.814Z | Extended Element | 5333560.1412099199,2184690.3295095777,361.04262739621839 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.824Z | Extended Element | 5333560.4459747747,2184690.3340556026,361.0436902073792 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.834Z | Extended Element | 5333560.7507396275,2184690.3386016265,361.04475301854012 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.845Z | Extended Element | 5333561.0555044794,2184690.3431476508,361.04581582970093 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.854Z | Extended Element | 5333561.3602693342,2184690.3476936747,361.04687864086179 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.872Z | Extended Element | 5333561.6650342401,2184690.3522396996,361.04792587482848 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.883Z | Extended Element | 5333561.9697993137,2184690.3567857263,361.04892306214094 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.892Z | Extended Element | 5333562.2745643901,2184690.3613317544,361.04992024945341 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.901Z | Extended Element | 5333562.5793294637,2184690.365877782,361.05091743676604 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.909Z | Extended Element | 5333562.8840945391,2184690.3704238092,361.05191462407851 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.926Z | Extended Element | 5333563.188859663,2184690.3749698377,361.05289623591949 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.936Z | Extended Element | 5333563.4936249452,2184690.3795158677,361.05382779924349 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.948Z | Extended Element | 5333563.7983902283,2184690.384061899,361.05475936256749 | 0.854589 | 2.02511e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.956Z | Extended Element | 5333564.1031555105,2184690.3886079285,361.05569092589144 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.966Z | Extended Element | 5333564.4079207927,2184690.393153959,361.0566224892155 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.983Z | Extended Element | 5333564.7126861205,2184690.3976999903,361.05753847856982 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.992Z | Extended Element | 5333565.0174515974,2184690.4022460235,361.05840441777616 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.001Z | Extended Element | 5333565.3222170733,2184690.4067920577,361.05927035698261 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.009Z | Extended Element | 5333565.6269825501,2184690.4113380909,361.06013629618906 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.018Z | Extended Element | 5333565.9317480261,2184690.4158841241,361.06100223539539 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.036Z | Extended Element | 5333566.2365135448,2184690.4204301587,361.06185260192774 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.046Z | Extended Element | 5333566.5412791977,2184690.4249761943,361.06265291689573 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.054Z | Extended Element | 5333566.8460448533,2184690.4295222303,361.06345323186378 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.064Z | Extended Element | 5333567.150810509,2184690.4340682663,361.06425354683176 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.075Z | Extended Element | 5333567.4555761646,2184690.4386143023,361.06505386179975 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.092Z | Extended Element | 5333567.7603418604,2184690.4431603393,361.06583860519891 | 0.854588 | 7.71374e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.102Z | Extended Element | 5333568.0651076799,2184690.4477063776,361.06657329581839 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.114Z | Extended Element | 5333568.3698734995,2184690.4522524159,361.06730798643775 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.123Z | Extended Element | 5333568.67463932,2184690.4567984543,361.06804267705735 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.134Z | Extended Element | 5333568.9794051405,2184690.4613444926,361.06877736767672 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.152Z | Extended Element | 5333569.2841709973,2184690.4658905319,361.06949648765601 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.160Z | Extended Element | 5333569.5889369678,2184690.4704365735,361.07016555382393 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.172Z | Extended Element | 5333569.8937029401,2184690.4749826137,361.0708346199919 | 0.854588 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.182Z | Extended Element | 5333570.1984689133,2184690.4795286553,361.07150368615987 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.192Z | Extended Element | 5333570.5032348847,2184690.484074695,361.07217275232767 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.209Z | Extended Element | 5333570.8080008896,2184690.4886207366,361.07282624862376 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.220Z | Extended Element | 5333571.1127669979,2184690.4931667792,361.07342969024683 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.230Z | Extended Element | 5333571.4175331071,2184690.4977128226,361.07403313187001 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.241Z | Extended Element | 5333571.7222992145,2184690.5022588647,361.07463657349314 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.251Z | Extended Element | 5333572.0270653227,2184690.5068049082,361.07524001511621 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.269Z | Extended Element | 5333572.3318314608,2184690.5113509507,361.07582788749073 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.279Z | Extended Element | 5333572.6365976902,2184690.5158969965,361.0763657044858 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.287Z | Extended Element | 5333572.9413639251,2184690.5204430409,361.07690352148109 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.295Z | Extended Element | 5333573.2461301554,2184690.5249890857,361.07744133847632 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.304Z | Extended Element | 5333573.5508963866,2184690.5295351301,361.07797915547155 | 0.854589 | 1.40057e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.319Z | Extended Element | 5333573.855662643,2184690.534081175,361.07850140371062 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.329Z | Extended Element | 5333574.1604289841,2184690.5386272217,361.0789735960015 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.340Z | Extended Element | 5333574.4651953243,2184690.543173268,361.07944578829256 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.350Z | Extended Element | 5333574.7699616654,2184690.5477193138,361.0799179805835 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.359Z | Extended Element | 5333575.0747280037,2184690.55226536,361.08039017287444 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.375Z | Extended Element | 5333575.3794943681,2184690.5568114072,361.08084679678814 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.384Z | Extended Element | 5333575.6842608033,2184690.5613574544,361.0812533643109 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.394Z | Extended Element | 5333575.9890272366,2184690.5659035025,361.08165993183366 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.403Z | Extended Element | 5333576.2937936699,2184690.5704495497,361.08206649935642 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.412Z | Extended Element | 5333576.5985601079,2184690.5749955978,361.08247306687917 | 0.854588 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.428Z | Extended Element | 5333576.9033265598,2184690.5795416459,361.08286406630288 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.438Z | Extended Element | 5333577.208093076,2184690.5840876941,361.08320500899998 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.447Z | Extended Element | 5333577.5128595913,2184690.588633744,361.08354595169703 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.457Z | Extended Element | 5333577.8176261047,2184690.5931797931,361.0838868943942 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.466Z | Extended Element | 5333578.1223926218,2184690.5977258417,361.0842278370913 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.485Z | Extended Element | 5333578.427159152,2184690.6022718907,361.08455321188342 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.492Z | Extended Element | 5333578.7319257343,2184690.6068179403,361.08482852970769 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.502Z | Extended Element | 5333579.0366923148,2184690.6113639902,361.08510384753203 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.513Z | Extended Element | 5333579.3414588971,2184690.6159100402,361.08537916535624 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.522Z | Extended Element | 5333579.6462254785,2184690.6204560902,361.08565448318052 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.540Z | Extended Element | 5333579.9509920729,2184690.6250021402,361.08591423322463 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.552Z | Extended Element | 5333580.2557587055,2184690.6295481911,361.08612392613782 | 0.854589 | 1.38194e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.560Z | Extended Element | 5333580.560525341,2184690.6340942415,361.08633361905089 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.568Z | Extended Element | 5333580.8652919745,2184690.638640292,361.08654331196402 | 0.854588 | 7.71374e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.576Z | Extended Element | 5333581.1700586071,2184690.6431863434,361.08675300487715 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.592Z | Extended Element | 5333581.4748252509,2184690.6477323938,361.08694713008089 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.602Z | Extended Element | 5333581.7795919226,2184690.6522784452,361.08709119805388 | 0.854589 | 1.38194e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.613Z | Extended Element | 5333582.0843585934,2184690.6568244961,361.08723526602671 | 0.854588 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.621Z | Extended Element | 5333582.3891252652,2184690.6613705475,361.08737933399965 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.632Z | Extended Element | 5333582.6938919397,2184690.6659165989,361.08752340197248 | 0.854589 | 2.00648e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.650Z | Extended Element | 5333582.9986586161,2184690.6704626507,361.08765190226779 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.659Z | Extended Element | 5333583.3034253111,2184690.6750087021,361.08773034528031 | 0.854588 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.670Z | Extended Element | 5333583.608192008,2184690.6795547535,361.08780878829282 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.681Z | Extended Element | 5333583.9129587039,2184690.6841008044,361.08788723130522 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.692Z | Extended Element | 5333584.217725399,2184690.6886468567,361.08796567431779 | 0.854589 | 1.40057e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.708Z | Extended Element | 5333584.5224920949,2184690.6931929081,361.08803092121946 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.719Z | Extended Element | 5333584.827258802,2184690.6977389599,361.08805373648357 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.730Z | Extended Element | 5333585.1320255063,2184690.7022850113,361.08807655174758 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.739Z | Extended Element | 5333585.4367922116,2184690.7068310636,361.08809936701169 | 0.854588 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.757Z | Extended Element | 5333585.7415589169,2184690.711377115,361.08809722481379 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.774Z | Extended Element | 5333586.0463256231,2184690.7159231664,361.08807707219813 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.785Z | Extended Element | 5333586.3510923246,2184690.7204692177,361.08802426526626 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.793Z | Extended Element | 5333586.6558590252,2184690.7250152701,361.08797145833449 | 0.854588 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.803Z | Extended Element | 5333586.9606257277,2184690.7295613214,361.08791865140273 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.812Z | Extended Element | 5333587.2653924273,2184690.7341073733,361.08786584447097 | 0.854588 | 1.40057e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.828Z | Extended Element | 5333587.5701591223,2184690.7386534247,361.08779746987682 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.838Z | Extended Element | 5333587.8749258071,2184690.7431994765,361.08767903797929 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.849Z | Extended Element | 5333588.179692491,2184690.747745527,361.08756060608181 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.858Z | Extended Element | 5333588.484459172,2184690.7522915788,361.08744217418422 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.868Z | Extended Element | 5333588.7892258568,2184690.7568376306,361.08732374228674 | 0.854588 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.884Z | Extended Element | 5333589.0939925313,2184690.7613836806,361.08718974275536 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.892Z | Extended Element | 5333589.3987591816,2184690.765929732,361.08700568590882 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.904Z | Extended Element | 5333589.7035258329,2184690.7704757834,361.08682162906217 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.915Z | Extended Element | 5333590.0082924813,2184690.7750218352,361.08663757221558 | 0.854588 | 7.71374e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.925Z | Extended Element | 5333590.3130591335,2184690.7795678852,361.08645351536899 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.942Z | Extended Element | 5333590.6178257717,2184690.7841139361,361.08625389095477 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.953Z | Extended Element | 5333590.9225923745,2184690.7886599866,361.08600420918452 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.964Z | Extended Element | 5333591.2273589782,2184690.793206037,361.08575452741445 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.973Z | Extended Element | 5333591.5321255829,2184690.7977520865,361.08550484564421 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:19.984Z | Extended Element | 5333591.8368921876,2184690.802298137,361.08525516387408 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.001Z | Extended Element | 5333592.1416587764,2184690.8068441874,361.08498991465461 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.009Z | Extended Element | 5333592.4464253178,2184690.8113902365,361.08467460799488 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.017Z | Extended Element | 5333592.751191861,2184690.815936286,361.08435930133533 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.026Z | Extended Element | 5333593.0559584051,2184690.8204823355,361.08404399467571 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.036Z | Extended Element | 5333593.3607249474,2184690.8250283836,361.08372868801598 | 0.854589 | 2.64033e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.052Z | Extended Element | 5333593.6654914701,2184690.8295744332,361.08339781409279 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.060Z | Extended Element | 5333593.9702579407,2184690.8341204817,361.08301688258877 | 0.854588 | 7.71374e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.071Z | Extended Element | 5333594.2750244075,2184690.8386665299,361.0826359510848 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.079Z | Extended Element | 5333594.5797908735,2184690.8432125775,361.08225501958066 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.088Z | Extended Element | 5333594.884557345,2184690.8477586266,361.08187408807669 | 0.854589 | 2.64499e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.106Z | Extended Element | 5333595.1893237904,2184690.8523046742,361.0814775895779 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.116Z | Extended Element | 5333595.4940901697,2184690.8568507214,361.08103103328136 | 0.854588 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.141Z | Extended Element | 5333595.798856548,2184690.8613967677,361.08058447698488 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.152Z | Extended Element | 5333596.1036229283,2184690.8659428144,361.08013792068834 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.163Z | Extended Element | 5333596.4083893048,2184690.8704888616,361.07969136439186 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.182Z | Extended Element | 5333596.7131556598,2184690.8750349088,361.07922924146754 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.193Z | Extended Element | 5333597.0179219358,2184690.8795809536,361.07871706044131 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.204Z | Extended Element | 5333597.3226882108,2184690.8841269989,361.07820487941507 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.216Z | Extended Element | 5333597.6274544867,2184690.8886730443,361.07769269838877 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.225Z | Extended Element | 5333597.9322207617,2184690.8932190905,361.07718051736248 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.242Z | Extended Element | 5333598.2369870106,2184690.8977651349,361.0766527701885 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.252Z | Extended Element | 5333598.5417531682,2184690.9023111784,361.0760749645035 | 0.854589 | 2.63567e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.265Z | Extended Element | 5333598.8465193277,2184690.9068572219,361.07549715881856 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.274Z | Extended Element | 5333599.1512854835,2184690.9114032653,361.07491935313357 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.285Z | Extended Element | 5333599.4560516439,2184690.9159493083,361.07434154744851 | 0.854589 | 1.40057e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.302Z | Extended Element | 5333599.7608177699,2184690.9204953518,361.07374817622463 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.311Z | Extended Element | 5333600.0655837972,2184690.9250413934,361.07310474596147 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.322Z | Extended Element | 5333600.3703498235,2184690.9295874354,361.07246131569855 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.333Z | Extended Element | 5333600.6751158526,2184690.934133477,361.07181788543534 | 0.854589 | 2.00648e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.341Z | Extended Element | 5333600.979881878,2184690.9386795186,361.0711744551723 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.356Z | Extended Element | 5333601.2846478699,2184690.9432255607,361.07051546012275 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.368Z | Extended Element | 5333601.5894137528,2184690.9477715995,361.06980640537046 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.376Z | Extended Element | 5333601.8941796329,2184690.9523176388,361.06909735061816 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.387Z | Extended Element | 5333602.1989455149,2184690.9568636781,361.06838829586587 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.395Z | Extended Element | 5333602.5037113959,2184690.9614097173,361.06767924111352 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.410Z | Extended Element | 5333602.8084772397,2184690.9659557561,361.06695462248581 | 0.854589 | 2.00648e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.423Z | Extended Element | 5333603.1132429596,2184690.9705017931,361.06617994334204 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.431Z | Extended Element | 5333603.4180086814,2184690.97504783,361.06540526419832 | 0.854588 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.440Z | Extended Element | 5333603.7227744032,2184690.979593867,361.06463058505454 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.449Z | Extended Element | 5333604.0275401259,2184690.9841399039,361.06385590591077 | 0.854588 | 7.71374e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.470Z | Extended Element | 5333604.3323058058,2184690.9886859409,361.06306566397717 | 0.854588 | 7.71374e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.480Z | Extended Element | 5333604.6370713525,2184690.993231975,361.06222536055236 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.489Z | Extended Element | 5333604.9418369001,2184690.9977780092,361.06138505712767 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.500Z | Extended Element | 5333605.2466024486,2184691.0023240438,361.06054475370297 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.510Z | Extended Element | 5333605.5513679972,2184691.0068700789,361.05970445027822 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.531Z | Extended Element | 5333605.8561335001,2184691.0114161121,361.05884858533778 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.546Z | Extended Element | 5333606.1608988596,2184691.0159621434,361.05794265774648 | 0.854589 | 2.63567e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.556Z | Extended Element | 5333606.4656642182,2184691.0205081762,361.05703673015512 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.569Z | Extended Element | 5333606.7704295786,2184691.0250542075,361.05613080256387 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.579Z | Extended Element | 5333607.0751949381,2184691.0296002394,361.05522487497251 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.595Z | Extended Element | 5333607.3799602492,2184691.0341462698,361.05430338734516 | 0.854589 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.605Z | Extended Element | 5333607.6847254066,2184691.0386922993,361.05333183571503 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.615Z | Extended Element | 5333607.9894905649,2184691.0432383269,361.05236028408484 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.625Z | Extended Element | 5333608.2942557232,2184691.0477843559,361.05138873245477 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.635Z | Extended Element | 5333608.5990208797,2184691.052330384,361.05041718082458 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.652Z | Extended Element | 5333608.9037859812,2184691.056876665,361.049429814706 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.662Z | Extended Element | 5333609.2085509049,2184691.0614237585,361.04839155874436 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.672Z | Extended Element | 5333609.5133158257,2184691.0659708516,361.0473533027826 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.682Z | Extended Element | 5333609.8180807494,2184691.0705179442,361.04631504682095 | 0.854588 | 1.3866e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.693Z | Extended Element | 5333610.1228456683,2184691.0750650372,361.04527679085925 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.718Z | Extended Element | 5333551.9460749002,2184689.1318312897,360.78193363915847 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.728Z | Extended Element | 5333552.2508386588,2184689.1363772973,360.78327474885776 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.739Z | Extended Element | 5333552.5556024136,2184689.1409233059,360.78461585855791 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.749Z | Extended Element | 5333552.8603661703,2184689.145469313,360.78595696825874 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.759Z | Extended Element | 5333553.1651299251,2184689.1500153211,360.78729807796151 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.768Z | Extended Element | 5333553.4698936809,2184689.1545613287,360.78863918765933 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.778Z | Extended Element | 5333553.7746574366,2184689.1591073368,360.7899802973613 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.789Z | Extended Element | 5333554.0794211905,2184689.1636533439,360.79132140706156 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.799Z | Extended Element | 5333554.3841849482,2184689.168199352,360.79266251676216 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.817Z | Extended Element | 5333554.6889488092,2184689.1727453615,360.79397934170788 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.825Z | Extended Element | 5333554.9937126711,2184689.1772913714,360.79529614327708 | 0.854589 | -1.59233e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.838Z | Extended Element | 5333555.298476534,2184689.1818373809,360.79661294484373 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.856Z | Extended Element | 5333555.6032404657,2184689.1863833917,360.7979129074842 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.868Z | Extended Element | 5333555.9080045689,2184689.190929404,360.79917258927048 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.877Z | Extended Element | 5333556.212768672,2184689.1954754167,360.80043227105534 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.888Z | Extended Element | 5333556.5175327752,2184689.200021429,360.80169195284225 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.899Z | Extended Element | 5333556.8222968783,2184689.2045674422,360.80295163462915 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.918Z | Extended Element | 5333557.1270610588,2184689.2091134563,360.80419197342434 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.927Z | Extended Element | 5333557.4318254273,2184689.2136594732,360.80538603183419 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.937Z | Extended Element | 5333557.736589794,2184689.2182054892,360.80658009024307 | 0.854589 | -1.59125e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.950Z | Extended Element | 5333558.0413541617,2184689.2227515061,360.80777414864957 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.958Z | Extended Element | 5333558.3461185284,2184689.2272975231,360.80896820705993 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.974Z | Extended Element | 5333558.6508829705,2184689.2318435414,360.81014292494638 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.985Z | Extended Element | 5333558.9556475878,2184689.2363895625,360.81127135981075 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:20.994Z | Extended Element | 5333559.2604122041,2184689.2409355831,360.81239979467477 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
