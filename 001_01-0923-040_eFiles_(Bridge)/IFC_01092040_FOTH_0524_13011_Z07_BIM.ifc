Properties of the parts of a building model (IFC4X3_ADD2), part 22 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.460Z | Extended Element | 5333589.6489088945,2184685.4210854243,361.06431193806498 | -89.1454 | 0.0000349733 | 179.978 | -0.0093051083118387348,-4.9371046238325223e-10,-0.0079375000010272669 | 0.0093054642734835026,10.922208943797061,0.030350169204491809
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.474Z | Extended Element | 5333579.8364615059,2184685.2747180793,361.06304549941268 | -89.1454 | -0.0000418064 | -179.948 | -0.0093038134497601191,3.3561131584799729e-10,-0.0079375000016340819 | 0.0093038714646975478,10.54599298408669,0.030772469721605772
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.485Z | Extended Element | 5333570.0240249187,2184685.1283508958,361.04839447677659 | -89.1454 | -0.0000751468 | -179.862 | -0.0093038706055991599,4.6433022056525556e-10,-0.0079375000003839378 | 0.0093039016813972596,9.8765114215439525,0.029857607836518005
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.495Z | Extended Element | 5333549.2909078496,2184684.8190854113,360.97418277359549 | -89.1454 | 180 | -0.2521 | -0.0079375086570926297,-2.5437305240444107e-10,-0.0079375000021595157 | 0.0079374999236360867,10.922026766023865,0.010277280423548574
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.551Z | Extended Element | 5333598.2513673063,2184685.2588585354,361.04398559036514 | -89.1454 | 0.000132166 | -0.108615 | -0.009304225536086088,-7.1267953683522208e-11,-0.009304225236155159 | 0.0093042255849965887,10.922230660248587,0.025205147021976158
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.562Z | Extended Element | 5333590.8011438483,2184685.1477273433,361.05377520450014 | 90.8546 | 0.0000324507 | 0.0222626 | -0.0093042252986669099,-8.5597724996553222,-0.0093042251844710575 | 0.0093042251213362667,1.6955075553354009,0.025205147034792465
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.575Z | Extended Element | 5333589.5475147301,2184685.129027579,361.07016328611468 | -89.1454 | 0.000250203 | 179.978 | -0.0093051223749048735,3.3955700561494593e-10,-0.0079375000009627144 | 0.009305157166026555,10.922208857846822,0.030486765558378127
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.589Z | Extended Element | 5333579.735067293,2184684.982660234,361.06876025101383 | -89.1454 | -0.0000850176 | -179.948 | -0.0093038098128859128,-2.3934603505612343e-11,-0.0079374999996020979 | 0.0093038423866932552,10.440254011061906,0.030931832054710753
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.603Z | Extended Element | 5333569.9226308847,2184684.8362930529,361.05394986625913 | -89.1454 | -0.000065895 | -179.862 | -0.0093038719168416321,-6.8191569971114825e-10,-0.0079374999996862077 | 0.0093043979104608914,9.770772362857441,0.029994204906480488
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.613Z | Extended Element | 5333549.1895144526,2184684.5270275776,360.97952778854301 | -89.1454 | 180 | -0.2521 | -0.0079375082358395643,-1.2780948304254778e-10,-0.0079375000016285533 | 0.0079375001178668449,10.92202679285367,0.010203500268112451
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.660Z | Extended Element | 5333600.5426413929,2184685.0898132576,361.04420459800417 | 90.8546 | -0.000325289 | 0.0962788 | -0.0093042260308229888,-8.5597735845593537,-0.0093042252133361206 | 0.0093042255987454241,2.2910631090626241,0.025205147076973872
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.672Z | Extended Element | 5333599.2890345436,2184685.0711139222,361.06221231631974 | -89.1454 | 0.000129422 | 179.904 | -0.0093039658791981422,-7.7509977321465346e-10,-0.007937500000170428 | 0.0093038668838632491,10.18131978525755,0.029463853858403218
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.686Z | Extended Element | 5333589.4765942199,2184684.9247466819,361.07425603244229 | -89.1454 | 0.000126678 | 179.978 | -0.0093051348030696018,7.5785352987788036e-10,-0.0079375000000568435 | 0.0093050950858194568,10.922208795322236,0.030582308360764539
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.700Z | Extended Element | 5333579.6641467512,2184684.7783793365,361.07275745446742 | -89.1454 | -0.0000621551 | -179.948 | -0.0093038110720997259,2.0829964683236195e-10,-0.0079375000017757012 | 0.009303863855729292,10.366294510982849,0.031043298404284877
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.715Z | Extended Element | 5333569.8517104695,2184684.6320121563,361.05783560332287 | -89.1454 | -0.0000511477 | -179.862 | -0.0093051004133401938,2.5478339247534649e-10,-0.007937500000797678 | 0.0093051497940981314,10.922208949220115,0.030343273762344209
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.726Z | Extended Element | 5333549.1185944807,2184684.3227466885,360.98326637837317 | -89.1454 | 180 | -0.2521 | -0.0079375091802214269,-4.3169484316425757e-10,-0.0079375000000703345 | 0.0079374998803386394,10.922026809715538,0.010151894470636968
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.776Z | Extended Element | 5333600.4717209814,2184684.8855324248,361.04850193368765 | 90.8546 | -0.0000896427 | 0.0962788 | -0.0093042253114609622,-8.5597738082237385,-0.0093042251489798729 | 0.0093042253001897907,2.2171036645124866,0.02520514755457124
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.790Z | Extended Element | 5333599.2181141898,2184684.8668330275,361.06650965189414 | -89.1454 | 0.0000842315 | 179.904 | -0.0093039203038704794,3.6229674811837088e-10,-0.0079375000001136887 | 0.0093038678473484557,10.107360398614945,0.029559396427022124
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.804Z | Extended Element | 5333589.4056737106,2184684.7204657849,361.0784578254341 | -89.1454 | 0.0000650804 | 179.978 | -0.0093051092029918167,5.5446241081087569e-10,-0.0079375000009275689 | 0.0093051090495124434,10.922208733132178,0.030677851169571245
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.819Z | Extended Element | 5333579.5932262093,2184684.574098438,361.07686370458521 | -89.1454 | -0.0000520405 | -179.948 | -0.0093038119420313786,6.7820082858245743e-11,-0.0079375000003410624 | 0.0093038533025555301,10.292335008620659,0.031154765073945396
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.832Z | Extended Element | 5333569.7807900542,2184684.4277312616,361.06183038704131 | -89.1454 | 0.0000395922 | -179.862 | -0.0093051072577242048,-4.8666955940111104e-10,-0.0079375000030917648 | 0.0093052064366407512,10.922208887445372,0.030438815824052702
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.843Z | Extended Element | 5333549.0476745088,2184684.1184657989,360.98711401486094 | -89.1454 | 180 | -0.2521 | -0.0079375072218584551,-7.9325994980021871e-10,-0.0079375000039526578 | 0.007937499928600834,10.922026827473406,0.010100288675192083
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.898Z | Extended Element | 5333608.9291344788,2184684.7211420364,361.04651197851871 | -89.1454 | -0.00000302261 | 179.817 | -0.009303815350855978,3.5449176917829347e-10,-0.0079375000026716443 | 0.0093038245863430805,10.671137219300009,0.03058735981195209
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.911Z | Extended Element | 5333599.1167202471,2184684.5747751859,361.07219521353011 | -89.1454 | 7.22552e-07 | 179.904 | -0.0093038822890088562,-7.447500215581526e-10,-0.0079374999993747225 | 0.0093038746314567482,10.001621588876001,0.029695992548138431
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.924Z | Extended Element | 5333589.3042795425,2184684.4284079401,361.08400679103249 | -89.1454 | 0.0000682027 | 179.978 | -0.0093040723453986039,-7.2639978028079791e-11,-0.0079375000020970136 | 0.0093038157705446923,10.856104639899458,0.030305090961589072
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.939Z | Extended Element | 5333579.4918317692,2184684.282040589,361.08250054045402 | -89.1454 | 0.0000424672 | -179.936 | -0.0093038867444401579,8.062618416120623e-10,-0.0079375000007373495 | 0.0093038718745352966,10.186595598013348,0.029457043596715395
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.952Z | Extended Element | 5333569.679396023,2184684.1356734186,361.06708339407999 | -89.1454 | -0.000160386 | -179.862 | -0.0093050932871303112,-3.0024852875494593e-10,-0.0079375000025891877 | 0.0093051509955489713,10.922208802751843,0.030575411129719211
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.966Z | Extended Element | 5333548.9462811109,2184683.8264079648,360.99215664734919 | -89.1454 | 180 | -0.2521 | -0.0079375168168324423,-5.0212850163385784e-10,-0.0079374999993198185 | 0.0079375003500815611,10.922026853514124,0.010026508516388298
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.019Z | Extended Element | 5333608.8271426959,2184684.4273605817,361.05071986669287 | -89.1454 | -0.0000662085 | 179.817 | -0.0093038124535805931,2.1580971151366065e-10,-0.0079374999992610339 | 0.0093038355260987304,10.564774534335029,0.03074413603168092
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.033Z | Extended Element | 5333599.0147279724,2184684.2809937252,361.07624213937413 | -89.1454 | -0.0000618998 | 179.904 | -0.0093038735444609284,1.2532807535060583e-10,-0.0079374999990905106 | 0.0093039165057220603,9.8952588072677052,0.029833394948669118
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.048Z | Extended Element | 5333589.2022870313,2184684.1346264766,361.0879163147867 | -89.1454 | 0.00011395 | 179.978 | -0.0093039380274261667,-4.2509624979916381e-10,-0.0079375000011217296 | 0.0093038077559827945,10.749741760746586,0.030465393502284402
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.062Z | Extended Element | 5333579.3898392143,2184683.9882591241,361.08624976125259 | -89.1454 | 0.0000484956 | -179.936 | -0.0093038935292618224,2.8827733843880004e-10,-0.0079375000003144777 | 0.0093038725351384001,10.080232619513813,0.029594445916355346
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.079Z | Extended Element | 5333569.5774036162,2184683.8418919547,361.07069521268136 | -89.1454 | -0.0000412161 | -179.862 | -0.0093051094577579069,4.4926665347373232e-10,-0.0079375000026584552 | 0.0093051078276355486,10.922208712900359,0.030712812548279126
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.089Z | Extended Element | 5333548.844289327,2184683.5326265115,360.99555684980464 | -89.1454 | 180 | -0.2521 | -0.0079375063087587031,-3.0302546196043468e-10,-0.0079375000041232019 | 0.0079374998891149125,10.92202687946209,0.0099522929311209735
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.144Z | Extended Element | 5333608.7251509121,2184684.1335791284,361.0532324007562 | -89.1454 | 0.000236528 | 179.817 | -0.0093038850253180042,2.6737410847186994e-11,-0.0079375000035430358 | 0.0093037996170739715,10.458411851804744,0.030904438074094282
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.157Z | Extended Element | 5333598.9127357015,2184683.9872122635,361.07859437244224 | -89.1454 | 0.0000587677 | 179.904 | -0.009303880515462418,1.8437437813336446e-10,-0.0079374999996219969 | 0.0093039518237443171,9.7888960267565963,0.029970797632108141
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.171Z | Extended Element | 5333589.1002945174,2184683.8408450112,361.09013114576857 | -89.1454 | -0.0000855531 | 179.978 | -0.0093038140019877022,-8.4038114699949022e-10,-0.0079375000012621797 | 0.0093038246967557525,10.643378881531927,0.030625696165034636
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.184Z | Extended Element | 5333579.2878466658,2184683.6944776597,361.08830428928388 | -89.1454 | 0.0000710269 | -179.936 | -0.0093039301369495214,-5.6632638339448821e-10,-0.0079374999994315659 | 0.0093038709062157852,9.9738696435378671,0.029731848832858381
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.197Z | Extended Element | 5333569.4754112093,2184683.548110493,361.07261233852279 | -89.1454 | -0.00019684 | -179.862 | -0.0093038060550656825,-2.9012316481903409e-10,-0.0079375000001003834 | 0.0093038323303278065,10.828401972326379,0.030346839911568217
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.208Z | Extended Element | 5333548.7422975441,2184683.2388450587,360.99726235950016 | -89.1454 | 179.999 | -0.2521 | -0.0079375144582115031,-1.0274488081966999e-10,-0.0079375000017249744 | 0.0079375003244688425,10.922025327110145,0.0096595790600019823
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.263Z | Extended Element | 5333608.6231591282,2184683.8397976747,361.05358298042898 | -89.1454 | -2.2235e-07 | 179.817 | -0.0093038165456885598,-2.2922138674895352e-10,-0.0079375000025897844 | 0.0093038602989914607,10.352049170160043,0.03106473928480985
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.275Z | Extended Element | 5333598.8107434288,2184683.6934308033,361.078784651126 | -89.1454 | -0.000146323 | 179.904 | -0.0093051739959202542,2.1793443470571519e-10,-0.007937499999147354 | 0.0093051132953058252,10.922208938775706,0.030361740890341098
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.290Z | Extended Element | 5333588.9983020062,2184683.5470635472,361.09018402235893 | -89.1454 | 0.000214201 | 179.978 | -0.0093038810530125995,5.5521690761189924e-12,-0.0079375000015290825 | 0.009303799411750616,10.537016002624858,0.03078599900834483
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.303Z | Extended Element | 5333579.1858541127,2184683.4006961938,361.0881968629223 | -89.1454 | 0.0000854234 | -179.936 | -0.0093039755781433413,5.3124389588995276e-10,-0.0079375000002735972 | 0.0093038704826575534,9.867506667608378,0.029869250940450582
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.316Z | Extended Element | 5333569.3734188015,2184683.2543290299,361.07236750995656 | -89.1454 | -0.0000692139 | -179.862 | -0.0093038308706234092,4.9965365127175862e-11,-0.0079374999986926067 | 0.0093038239023371279,10.72203889645535,0.030507141634072938
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.327Z | Extended Element | 5333548.6403057594,2184682.9450636054,360.9968059148091 | -89.1454 | 180 | -0.2521 | -0.0079375058756702803,-4.1698543728243089e-10,-0.0079375000059654002 | 0.0079375000843571984,10.922025337286639,0.0096082636221215545
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.384Z | Extended Element | 5333599.9623574736,2184683.4183487855,361.05878265210168 | 90.8546 | 0.00010296 | 0.0962788 | -0.009304225890913979,-8.5597736878711697,-0.0093042250730439313 | 0.0093042249260035861,1.6859132569734272,0.025205146869666122
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.398Z | Extended Element | 5333598.708751156,2184683.3996493425,361.07679036950714 | -89.1454 | 0.00000166213 | 179.904 | -0.0093051670528951948,-2.8465851901210057e-10,-0.0079374999998863185 | 0.0093051032971880211,10.922208848628827,0.030499143064595041
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.411Z | Extended Element | 5333588.896309494,2184683.2532820818,361.0880523386532 | -89.1454 | 0.0000948462 | 179.978 | -0.0093038675138699418,1.1387233464386115e-10,-0.0079375000027143497 | 0.0093038096560317651,10.430653125842657,0.030946302396356082
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.425Z | Extended Element | 5333579.0838615596,2184683.1069147293,361.08590487626219 | -89.1454 | -0.0000324934 | -179.936 | -0.0093044517283699009,3.1279297344296464e-11,-0.0079375000006564923 | 0.0093038802018148258,9.7611436891279819,0.030006654293010214
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.440Z | Extended Element | 5333569.2714263946,2184682.9605475669,361.06993812110602 | -89.1454 | -0.000168481 | -179.862 | -0.0093038045265792513,2.5149461444716512e-10,-0.0079375000025233428 | 0.0093038597828576861,10.615675822355563,0.030667443321418023
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.454Z | Extended Element | 5333548.5383139737,2184682.6512821517,360.99416490981787 | -89.1454 | 179.999 | -0.2521 | -0.0079375139699418319,6.5510527673313583e-11,-0.0079374999986926032 | 0.0079374998651807853,10.92202534921255,0.0095569481789185579
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.507Z | Extended Element | 5333599.8603651049,2184683.124567295,361.05499965026735 | 90.8546 | -0.00000192259 | 0.0962788 | -0.0093042257100136114,-8.559774004925865,-0.0093042251864275984 | 0.0093042251967525944,1.5795503786967071,0.02520514756323796
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.519Z | Extended Element | 5333598.6067588851,2184683.1058678823,361.0730073675112 | -89.1454 | -0.0000640767 | 179.904 | -0.0093051268770136183,2.4700408794540929e-10,-0.0079375000013072877 | 0.0093051068914905867,10.922208761423219,0.030636545236489583
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.534Z | Extended Element | 5333588.7943169829,2184682.9595006183,361.0841319345688 | -89.1454 | 0.0000522741 | 179.978 | -0.0093038529604892051,-5.7334889276085626e-11,-0.0079375000030931387 | 0.0093038119822857514,10.324290247825951,0.031106604513624358
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.549Z | Extended Element | 5333578.9818690112,2184682.8131332644,361.08182416922887 | -89.1454 | 0.00013194 | -179.936 | -0.0093051123503614178,8.854356784073311e-11,-0.0079374999995452528 | 0.0093052500826663973,10.922208915739274,0.030397592864939114
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.565Z | Extended Element | 5333569.1694339877,2184682.6667661043,361.06572001187834 | -89.1454 | -0.000193121 | -179.862 | -0.009303801739974419,-9.6672277729053382e-11,-0.0079375000018409182 | 0.0093038588228706153,10.509312748658456,0.030827744745405099
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.576Z | Extended Element | 5333548.436322188,2184682.3575006975,360.98973518444222 | -89.1454 | 180 | -0.2521 | -0.0079375042568013178,-9.7002406662390654e-12,-0.0079375000011368806 | 0.0079375000347331054,10.922025364396156,0.0095056327533730774
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.634Z | Extended Element | 5333599.7589711249,2184682.8325094632,361.0496811777677 | 90.8546 | 0.000037629 | 0.0962788 | -0.0093042257128695318,-8.5597743195433207,-0.0093042252691551818 | 0.0093042259247438641,1.4738115339176927,0.025205147306878419
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.649Z | Extended Element | 5333598.505365001,2184682.8138100412,361.06768889484533 | -89.1454 | -0.000077129 | 179.904 | -0.0093040629384331767,-3.4328306866602506e-10,-0.0079374999994884128 | 0.009303825348015925,10.888072537986799,0.030256903825584609
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.662Z | Extended Element | 5333588.6929229256,2184682.6674427753,361.07890821570032 | -89.1454 | -0.000469639 | 179.99 | -0.0093038437903687019,1.7314227934859153e-10,-0.0079375000007851221 | 0.009304065794348634,10.218550964498171,0.029415765409054218
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.675Z | Extended Element | 5333578.8804748515,2184682.5210754192,361.07620973816103 | -89.1454 | 0.0000881488 | -179.936 | -0.0093051101480767558,-2.0045072157510731e-10,-0.0079375000023102719 | 0.0093051448761441256,10.92220882771255,0.030534188865822924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.690Z | Extended Element | 5333569.0680399733,2184682.3747082618,361.05996898475883 | -89.1454 | -0.00012889 | -179.862 | -0.0093038062446925748,1.9716674818198941e-10,-0.0079375000028100058 | 0.0093038371060159396,10.40357370857766,0.030987105840521278
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.705Z | Extended Element | 5333548.3349287938,2184682.0654428648,360.98377378273545 | -89.1454 | 180 | -0.2521 | -0.007937505116265748,5.5262523618592372e-11,-0.0079374999980337344 | 0.0079375003680352985,10.922025375905514,0.0094546183933254483
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.757Z | Extended Element | 5333599.688050746,2184682.6282286202,361.04571862248793 | 90.8546 | 0.000230219 | 0.0962788 | -0.0093042267384363629,-8.5597745381610579,-0.0093042252606515708 | 0.0093042257217056563,1.3998521220698055,0.025205147056132905
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.772Z | Extended Element | 5333598.4344446892,2184682.609529146,361.06372633944909 | -89.1454 | 0.000183478 | 179.904 | -0.0093039051912916556,1.4427560788590038e-10,-0.0079375000023799817 | 0.0093038030144203358,10.814113192659075,0.030368369537643963
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.786Z | Extended Element | 5333588.6220024424,2184682.4631618788,361.07483419398142 | -89.1454 | 0.000024869 | 179.99 | -0.0093038794388980682,-2.4768819347583119e-10,-0.0079375000006927723 | 0.0093039190863577464,10.14459155245625,0.029511307645191207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.798Z | Extended Element | 5333578.8095543459,2184682.3167945226,361.07204017360681 | -89.1454 | -0.000035269 | -179.936 | -0.0093051003403312096,-5.268664948927593e-10,-0.0079374999995452528 | 0.0093051404165571134,10.922208765395865,0.030629731429750732
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.811Z | Extended Element | 5333568.9971195674,2184682.1704273648,361.05570387760901 | -89.1454 | -0.0000796222 | -179.862 | -0.0093038101336182979,5.9192035027148654e-10,-0.0079375000046004486 | 0.0093038526032813863,10.329614161931275,0.031098571370325512
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.823Z | Extended Element | 5333548.264008821,2184681.8611619747,360.97936152833319 | -89.1454 | 180 | -0.2521 | -0.0079375043325046555,5.0995024260212886e-10,-0.007937500001668072 | 0.0079375001980369723,10.92202538303588,0.0094189361920236254
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.877Z | Extended Element | 5333599.617130368,2184682.4239476379,361.04190879437846 | 90.8546 | -0.0000897351 | 0.0962788 | -0.009304225293223993,-8.5597747574019092,-0.0093042251165828833 | 0.009304225318836316,1.3258927095989519,0.025205147572105898
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.892Z | Extended Element | 5333598.3635243792,2184682.4052482527,361.05991651123105 | -89.1454 | -0.00002393 | 179.904 | -0.0093038171246733956,-7.3286311995039582e-11,-0.0079375000008445936 | 0.0093038661604100126,10.740153847576519,0.030479836170195337
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.906Z | Extended Element | 5333588.5510819601,2184682.2588809817,361.0709128994414 | -89.1454 | 0.0000280545 | 179.99 | -0.0093038929270387802,-6.405750652420221e-10,-0.0079374999999431567 | 0.0093038724015778226,10.070632139487856,0.029606850377767648
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.922Z | Extended Element | 5333578.7386338413,2184682.112513626,361.06802333623102 | -89.1454 | 0.0000684162 | -179.936 | -0.0093051095106672782,2.2548757303394579e-10,-0.0079375000005115926 | 0.0093051526213119001,10.922208704159985,0.030725273990977776
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.936Z | Extended Element | 5333560.3674833179,2184681.8384803743,361.01072355764177 | 90.8546 | -0.000124662 | -0.224457 | -0.0093042265855271689,-8.5597743381198406,-0.0093042251724563905 | 0.0093042252603504107,1.6958807205538702,0.025205146799216441
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:02.946Z | Extended Element | 5333548.1930888491,2184681.6568810856,360.97510200110304 | -89.1454 | 179.999 | -0.2521 | -0.0079375118953832861,6.5201634237678233e-10,-0.0079375000002026106 | 0.0079375005036932417,10.92202539557605,0.0093832540187739604
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.002Z | Extended Element | 5333599.5157363862,2184682.1318898168,361.03612986875407 | 90.8546 | -0.00000874372 | 0.0962788 | -0.0093042256299758676,-8.5597750749841328,-0.0093042252235209441 | 0.0093042259982528373,1.2201538618578063,0.02520514679078581
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.017Z | Extended Element | 5333598.2621304961,2184682.1131904116,361.05413758543727 | -89.1454 | -0.0000363463 | 179.904 | -0.0093038164043919343,-4.9025403603430428e-10,-0.0079375000035303254 | 0.0093038597668983376,10.634415098609239,0.030639198086129575
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.029Z | Extended Element | 5333588.4496878358,2184681.9668231369,361.0649746116423 | -89.1454 | 0.0000479011 | 179.99 | -0.009303910280393058,-4.6482690941644308e-10,-0.0079375000008639045 | 0.0093038712576389935,9.9648932928854936,0.029743447570934792
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.043Z | Extended Element | 5333578.6372396806,2184681.8204557807,361.06194845203828 | -89.1454 | 0.0000899435 | -179.936 | -0.0093038522007597782,-4.0078877930446809e-10,-0.0079375000006179919 | 0.009303810599249545,10.81939178037625,0.030360424625652221
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.058Z | Extended Element | 5333568.8248046013,2184681.6740886183,361.04559657777321 | -89.1454 | 0.000109132 | -179.85 | -0.0093038821328702871,-1.3704315463354218e-10,-0.0079375000000568505 | 0.009303895829203903,10.149915133200619,0.029504420909922665
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.072Z | Extended Element | 5333548.0916954521,2184681.3648232524,360.96868014627137 | -89.1454 | 180 | -0.2521 | -0.0079375117696112961,2.1199755013557548e-10,-0.0079374999993858247 | 0.0079374999134712299,10.922025405626151,0.0093322396477640516
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.128Z | Extended Element | 5333597.0515551763,2184681.8028726033,361.03444631857099 | -89.1454 | 0.000610134 | -0.0962788 | -0.009304225310885858,4.0829595641541904e-10,-0.0093042252259754755 | 0.0093042258221684715,10.922230349845856,0.025205147513424009
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.144Z | Extended Element | 5333598.1601382243,2184681.8194089509,361.04848421163649 | -89.1454 | -0.0000406532 | 179.904 | -0.0093038159124016525,-1.5915292145100109e-10,-0.0079375000016546869 | 0.0093038411093360977,10.5280523193245,0.030799500949979144
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.158Z | Extended Element | 5333588.3476953153,2184681.6730416729,361.05916093533494 | -89.1454 | -0.000521517 | 179.99 | -0.0093038372346675863,2.7140738311919801e-10,-0.0079375000009022523 | 0.009304218525154704,9.8585304157759914,0.029880850412779519
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.172Z | Extended Element | 5333578.5352471285,2184681.5266743158,361.05599737319079 | -89.1454 | 0.0000369772 | -179.936 | -0.0093038207508848014,5.7216557851199654e-10,-0.00793750000103563 | 0.00930383921372392,10.713028804321308,0.03052072718135922
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.187Z | Extended Element | 5333568.7228122512,2184681.3803071566,361.03948519648696 | -89.1454 | 0.0000911095 | -179.85 | -0.0093038807742566766,-1.411426000434171e-10,-0.0079375000010650978 | 0.0093039096801650397,10.043552058894569,0.029641821761276482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.199Z | Extended Element | 5333547.9897036683,2184681.0710417982,360.96238004908975 | -89.1454 | 180 | -0.2521 | -0.0079375044425205373,2.1779582645286274e-10,-0.0079375000044705196 | 0.0079375005648964561,10.922025417076036,0.0092809242121179615
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.255Z | Extended Element | 5333596.9495630004,2184681.509091177,361.02876804886608 | -89.1454 | 0.000491667 | -0.0962788 | -0.0093042251618398585,7.6525738553793131e-11,-0.009304225082000862 | 0.0093042258033746716,10.922230470628795,0.025205147248161936
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.269Z | Extended Element | 5333598.0581459543,2184681.5256274897,361.0428059421028 | -89.1454 | 0.0000564837 | 179.904 | -0.00930382259532961,-4.9077771579734899e-12,-0.0079375000019359342 | 0.0093038221539715575,10.421689537952821,0.030959803642034895
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.284Z | Extended Element | 5333588.2457027957,2184681.379260208,361.05332236330167 | -89.1454 | 0.000521038 | 179.99 | -0.0093039215522838642,2.0956717668969415e-10,-0.0079375000011772581 | 0.009304428337543847,9.7521675359623483,0.030018253471052386
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.297Z | Extended Element | 5333578.4332545763,2184681.2328928504,361.05002139862103 | -89.1454 | 0.000149785 | -179.936 | -0.0093039526057639849,-3.3620876028581357e-10,-0.0079375000025662581 | 0.0093038072329817458,10.606665828292511,0.030681030008747664
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.311Z | Extended Element | 5333568.620819902,2184681.0865256945,361.0333489194802 | -89.1454 | 0.0000730543 | -179.85 | -0.0093038810329308542,-2.8290824695419196e-10,-0.0079374999985789164 | 0.0093039161103639963,9.9371889844494419,0.029779223167135722
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.325Z | Extended Element | 5333547.8877118845,2184680.7772603449,360.95605505618875 | -89.1454 | 180 | -0.2521 | -0.0079375104498650654,-3.9237284167382943e-10,-0.0079374999978983913 | 0.0079375005180077288,10.922025428863634,0.0092296087732278292
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.381Z | Extended Element | 5333596.8475708226,2184681.2153098322,361.02323236429817 | -89.1454 | 0.0000865112 | -0.0962788 | -0.0093042255972671812,-1.8793610396937144e-10,-0.0093042251998988745 | 0.0093042252504895347,10.922230592435549,0.025205147297596493
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.395Z | Extended Element | 5333597.9561536796,2184681.2318460294,361.03727025770269 | -89.1454 | -0.000240138 | 179.904 | -0.0093037994626752173,-2.4843326993483862e-10,-0.0079375000030804284 | 0.0093039476659767494,10.315326757138472,0.031120106885455318
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.409Z | Extended Element | 5333588.1437102761,2184681.085478744,361.04762637639578 | -89.1454 | -0.000483093 | 179.99 | -0.00930506561958723,-5.4430751604907185e-11,-0.007937500000056847 | 0.0093052616841766533,10.922208906089294,0.030409196106641136
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.426Z | Extended Element | 5333578.3312620232,2184680.939111386,361.0441880091721 | -89.1454 | -0.000011234 | -179.936 | -0.0093038588050074686,-6.8391903314954475e-11,-0.0079375000000568435 | 0.0093038179096370487,10.500302847716458,0.030841332552568639
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.441Z | Extended Element | 5333568.5188275492,2184680.7927442333,361.02735522759053 | -89.1454 | 0.0000498561 | -179.85 | -0.0093038797641085327,1.0966270377320133e-11,-0.0079375000013709781 | 0.0093039952995040993,9.8308259085349974,0.029916624709817513
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.453Z | Extended Element | 5333547.7857200997,2184680.4834788912,360.94987264839358 | -89.1454 | 180 | -0.2521 | -0.0079375036545635408,-3.2987424798381419e-10,-0.0079375000039468204 | 0.0079375001597544546,10.922025438463123,0.0091782933260053032
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.510Z | Extended Element | 5333599.1077711126,2184680.9567639297,361.01396580321625 | 90.8546 | -0.000388497 | 0.0839427 | -0.0093042260469827238,-8.5597762465934917,-0.0093042252296699057 | 0.0093042253593419773,2.3187075465392351,0.025205147261872649
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.526Z | Extended Element | 5333597.8541617654,2184680.9380645733,361.03170358242102 | -89.1454 | -0.0000445197 | 179.916 | -0.0093038723501979222,1.468343224614e-10,-0.0079375000003410658 | 0.0093038999597087058,10.20896353732728,0.029428146424922166
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.544Z | Extended Element | 5333588.0417177593,2184680.7916972782,361.0416701146159 | -89.1454 | 0.0000731141 | 179.99 | -0.0093052289403967193,-1.2123909155690411e-10,-0.0079375000019719002 | 0.0093050972150596819,10.9222088182853,0.03054659852580956
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.559Z | Extended Element | 5333578.2292694738,2184680.6453299206,361.038094344858 | -89.1454 | -0.0000532983 | -179.936 | -0.0093038122176294542,2.9572094395088622e-10,-0.0079375000010024951 | 0.0093038314176187818,10.393939874868884,0.0310016348384855
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.572Z | Extended Element | 5333568.4168352038,2184680.4989627707,361.02110126084966 | -89.1454 | 0.0000935666 | -179.85 | -0.0093053411195966659,-3.5143949277484559e-10,-0.0079375000024908982 | 0.0093050976356889286,10.922208973395239,0.030307550305395555
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.585Z | Extended Element | 5333547.683728314,2184680.1896974389,360.94342996574397 | -89.1454 | 179.999 | -0.2521 | -0.0079375104228744543,5.3457772232099777e-10,-0.0079374999997157969 | 0.0079374998350770689,10.922025454585787,0.0091269778873835309
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.642Z | Extended Element | 5333599.0057787085,2184680.6629825803,361.00827708146483 | 90.8546 | 0.0000346363 | 0.0839427 | -0.0093042256649398768,-8.5597765977093978,-0.0093042252531138521 | 0.0093042255553942421,2.2123446704398733,0.025205147551316864
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.655Z | Extended Element | 5333597.7521694591,2184680.6442831121,361.02601486056204 | -89.1454 | -0.000096996 | 179.916 | -0.0093038704468597338,-1.7205305176941076e-10,-0.0079375000001938641 | 0.0093039367910467442,10.102600759299214,0.029565548393331153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.671Z | Extended Element | 5333587.9397252388,2184680.4979158146,361.03584399056456 | -89.1454 | 0.00000242555 | 179.99 | -0.0093051253867191194,-3.2695050837989035e-10,-0.007937500000056847 | 0.0093051019285453687,10.922208728433207,0.030684000937192465
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.686Z | Extended Element | 5333578.1272769226,2184680.3515484552,361.03213081827204 | -89.1454 | 0.000171104 | -179.936 | -0.0093038815355590415,1.7321281884303175e-10,-0.0079375000021665067 | 0.0093038037933761315,10.287576900579582,0.031161937456848435
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.699Z | Extended Element | 5333568.3148428556,2184680.205181309,361.01497743181955 | -89.1454 | 0.00007219 | -179.85 | -0.0093051089169789575,-8.2719410461046669e-10,-0.0079375000017866178 | 0.0093051043125372112,10.92220888422824,0.030444951523790353
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.709Z | Extended Element | 5333547.5817365302,2184679.8959159846,360.93711742082206 | -89.1454 | 179.999 | -0.2521 | -0.0079375102030845406,-4.0698733275763612e-10,-0.0079375000012505571 | 0.0079374998104957892,10.92202546699567,0.0090756624552969997
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.768Z | Extended Element | 5333607.4631965021,2184680.4985922216,360.99679698301782 | -89.1454 | -0.0000154678 | 179.83 | -0.0093038971700017958,3.6473384496805929e-11,-0.0079375000015784319 | 0.0093038211049156858,10.666381087245297,0.030591007779291017
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.783Z | Extended Element | 5333597.6507755443,2184680.3522252706,361.02035951392077 | -89.1454 | -0.000109673 | 179.916 | -0.0093038689890964331,2.5660422957344715e-10,-0.0079375000013646412 | 0.0093039034645867342,9.9968620111774804,0.02970214476987669
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.797Z | Extended Element | 5333587.8383311117,2184680.2058579703,361.03005204787269 | -89.1454 | -0.000508098 | 179.99 | -0.0093037761753075286,8.686872058609642e-10,-0.0079375000003465163 | 0.0093040339898110645,10.8513444946951,0.030312267502978888
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.810Z | Extended Element | 5333578.0258824881,2184680.0594906067,361.02642572055942 | -89.1454 | -0.0000785627 | -179.924 | -0.0093038704413150371,4.1859172010298555e-10,-0.0079375000009313228 | 0.0093038981085459271,10.181837518087837,0.029463191828912577
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.824Z | Extended Element | 5333568.2134488961,2184679.9131234675,361.00888953079323 | -89.1454 | -0.0000432726 | -179.85 | -0.0093051001973941672,3.4635897545468144e-11,-0.0079375000011706106 | 0.009305227559329117,10.922208797351447,0.03058154659673722
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.836Z | Extended Element | 5333547.4803431313,2184679.603858151,360.93084191108369 | -89.1454 | 180 | -0.2521 | -0.0079375037882736758,6.4026925514595922e-10,-0.0079375000038233497 | 0.0079374997871228363,10.922025479487289,0.0090246480857703523
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.895Z | Extended Element | 5333607.3922765283,2184680.2943113321,360.99295279605354 | -89.1454 | -0.0000941057 | 179.83 | -0.0093038099930234687,-8.3615207845905213e-11,-0.0079375000015339762 | 0.0093038744623352987,10.592421859564524,0.030702473793476504
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.910Z | Extended Element | 5333597.5798552455,2184680.1479443773,361.0164038615888 | -89.1454 | -0.000118237 | 179.916 | -0.0093038680667742561,-3.1773792730737683e-10,-0.0079375000005115926 | 0.0093039242666692803,9.9229027077001852,0.02979768748081664
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.925Z | Extended Element | 5333587.7674106592,2184680.0015770737,361.02600085300014 | -89.1454 | 0.0000276472 | 179.99 | -0.0093038222176984389,1.3949661785202127e-10,-0.0079375000012154723 | 0.0093038859722762851,10.777385112863623,0.030423733766703522
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.939Z | Extended Element | 5333577.9549620217,2184679.8552097101,361.02226305910818 | -89.1454 | 0.0000853917 | -179.924 | -0.0093038841205443819,-1.4430079045132573e-10,-0.0079375000014076779 | 0.0093038716137577686,10.10787805917535,0.029558734018490601
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.953Z | Extended Element | 5333568.1425285414,2184679.7088425723,361.004631326842 | -89.1454 | 0.0000488585 | -179.85 | -0.0093051077047213958,-8.8828948186894259e-13,-0.0079374999987494466 | 0.0093051416849702171,10.922208736280846,0.030677088510219105
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:03.962Z | Extended Element | 5333547.4094231613,2184679.3995772623,360.92645248354637 | -89.1454 | 180 | -0.2521 | -0.0079375037888511583,1.7725690681345779e-10,-0.0079375000068901067 | 0.0079375000263777057,10.922025486653661,0.0089889658999389773
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.021Z | Extended Element | 5333607.3213565564,2184680.0900304434,360.98910860926276 | -89.1454 | 0.000170706 | 179.83 | -0.0093038444789862972,1.4360119575204984e-10,-0.0079375000020458462 | 0.0093038045602325641,10.518462631276229,0.030813939579797386
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.036Z | Extended Element | 5333597.5089349477,2184679.943663483,361.01244820943231 | -89.1454 | -0.0000763309 | 179.916 | -0.0093040203164938447,-2.0767285154602233e-10,-0.0079375000000218333 | 0.0093038819115817059,9.8489434010931269,0.029893230741873816
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.049Z | Extended Element | 5333587.6964902058,2184679.7972961771,361.02194965830108 | -89.1454 | 0.0000122367 | 179.99 | -0.0093038564893838972,1.2713757216782619e-10,-0.0079375000012704214 | 0.0093038149916682272,10.703425727933089,0.030535200548585571
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.063Z | Extended Element | 5333577.8840415534,2184679.6509288135,361.01810039782123 | -89.1454 | -0.0000746368 | -179.924 | -0.0093039869146015874,1.7411015131072664e-11,-0.0079375000004997739 | 0.0093038817218854247,10.033918595263176,0.029654276929112697
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.078Z | Extended Element | 5333568.071608183,2184679.5045616771,361.00037312305898 | -89.1454 | -0.000036132 | -179.85 | -0.0093038166844161274,5.1893467296283895e-10,-0.007937499998976822 | 0.0093039715630958628,10.888456824649186,0.030256331883827314
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.089Z | Extended Element | 5333547.3385031894,2184679.1952963723,360.92206305616213 | -89.1454 | 180 | -0.2521 | -0.0079375074725957038,5.7379515350571957e-10,-0.0079374999971935159 | 0.0079375004014250738,10.922023873465177,0.0087218558261509243
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.146Z | Extended Element | 5333607.2199631603,2184679.7979726088,360.98361262369184 | -89.1454 | 0.0000109656 | 179.83 | -0.0093038599734655576,7.5929262852503251e-11,-0.0079375000001136869 | 0.0093038183159058832,10.412724050503405,0.03097330093384365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.160Z | Extended Element | 5333597.4075410869,2184679.6516056424,361.00679286322071 | -89.1454 | -0.000103683 | 179.916 | -0.0093143296439374065,1.7296633146115446e-10,-0.0079375000010051319 | 0.0093039129470397254,9.7432047082282836,0.030029852311884479
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.173Z | Extended Element | 5333587.5950961206,2184679.5052383333,361.01615771611006 | -89.1454 | 0.0000849613 | 179.99 | -0.0093038259545757482,-2.2057549341375231e-10,-0.0079375000013586928 | 0.0093038310835871479,10.597686923721907,0.030694562854292683
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.187Z | Extended Element | 5333577.7826474495,2184679.3588709701,361.01214909324875 | -89.1454 | -0.0000766128 | -179.924 | -0.009303869594250367,1.2526083673176619e-10,-0.0079375000016134491 | 0.0093038998377944042,9.9281796789732457,0.029790872626290477
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.200Z | Extended Element | 5333567.9702142403,2184679.2125038351,360.99428522257767 | -89.1454 | 0.000124849 | -179.85 | -0.0093038742484909051,1.6641970775192979e-10,-0.0079375000008526531 | 0.0093038093121735783,10.782717799181105,0.030415691757812852
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.210Z | Extended Element | 5333547.2371097906,2184678.9032385405,360.91578754694268 | -89.1454 | 179.999 | -0.2521 | -0.0079375083351998672,2.4120426839786954e-10,-0.0079375000004866334 | 0.0079375000099936102,10.922023876947296,0.0086936072072872541
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.271Z | Extended Element | 5333607.1179713774,2184679.5041911555,360.97808420241307 | -89.1454 | 0.0000478931 | 179.83 | -0.0093038583808574028,-2.8565727564196028e-10,-0.0079375000007389715 | 0.0093038151583989155,10.30636143741752,0.031133602503905029
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.285Z | Extended Element | 5333597.3055488337,2184679.3578241817,361.0011041408161 | -89.1454 | -0.0000643023 | 179.916 | -0.0093050991219651366,3.2783575405890141e-10,-0.0079374999991473506 | 0.009305192455951317,10.922208901696351,0.030420768389855135
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.298Z | Extended Element | 5333587.4931036448,2184679.2114568693,361.01033159158783 | -89.1454 | -0.000382986 | 179.99 | -0.0093037810443383044,-4.9394142924903613e-10,-0.0079375000027524182 | 0.009303987746922952,10.491324087565989,0.030854866100013631
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.313Z | Extended Element | 5333577.680654956,2184679.0650895052,361.00616266584905 | -89.1454 | -0.000130268 | -179.924 | -0.0093038672071713777,-4.7764012856770376e-10,-0.0079375000029345624 | 0.0093039817165959729,9.8218167337685891,0.029928275249130457
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.328Z | Extended Element | 5333567.8682219032,2184678.9187223734,360.98816139312464 | -89.1454 | 0.000136952 | -179.85 | -0.0093039454121281069,4.6905192875835502e-10,-0.0079374999987494484 | 0.0093038085270605586,10.676354737578757,0.030575993910288455
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.340Z | Extended Element | 5333547.1351180077,2184678.6094570858,360.90947500154738 | -89.1454 | 180 | -0.2521 | -0.0079375021943895192,-5.6060884558212818e-11,-0.0079374999975270425 | 0.0079375006671679078,10.922023882372081,0.0086651918767597595
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.396Z | Extended Element | 5333598.4571652394,2184679.0827421867,360.97767764056255 | 90.8546 | 0.0000552048 | 0.0839427 | -0.0093042256938467276,-8.5597767545640764,-0.0093042251883787216 | 0.0093042253985406494,1.640222579670445,0.025205146772758771
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.410Z | Extended Element | 5333597.2035565805,2184679.0640427214,360.99541541878671 | -89.1454 | -0.0000864473 | 179.916 | -0.0093050975657468574,-3.3672212905042548e-10,-0.0079375000000242394 | 0.0093052108862077213,10.922208809480889,0.030558170549188839
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.423Z | Extended Element | 5333587.3911111671,2184678.9176754057,361.0045054674402 | -89.1454 | -0.000445182 | 179.99 | -0.0093037747296613512,-2.9662378600671909e-10,-0.0079375000015818684 | 0.0093040340506761118,10.384961249970583,0.031015168812979877
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.437Z | Extended Element | 5333577.5786624588,2184678.7713080421,361.0001762388207 | -89.1454 | -0.0000736552 | -179.924 | -0.0093054998955137448,-1.9565078246482284e-10,-0.0079375000006757634 | 0.0093051107425149472,10.922208965991461,0.030319211495805663
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.451Z | Extended Element | 5333567.7662295671,2184678.6249409122,360.98203756404456 | -89.1454 | 0.0000617075 | -179.85 | -0.0093039077908587103,1.2928960381121345e-10,-0.0079374999986357633 | 0.0093038126203238269,10.569991677241486,0.030736295233530792
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.462Z | Extended Element | 5333547.0331262229,2184678.3156756326,360.90316245653054 | -89.1454 | 180 | -0.2521 | -0.0079375031601201917,3.5939057009463897e-10,-0.0079375000042859571 | 0.0079375001781820127,10.922023883741424,0.0086367765370177815
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.513Z | Extended Element | 5333598.3551728772,2184678.7889607633,360.97198891825116 | 90.8546 | 0.000199708 | 0.0839428 | -0.0093042254913642351,-8.5597770977593672,-0.0093042250206328767 | 0.0093042253708417143,1.5338597458164269,0.02520514693524456
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.527Z | Extended Element | 5333597.101564331,2184678.7702612602,360.98972669631235 | -89.1454 | -0.00011226 | 179.916 | -0.0093050967463498818,8.8980574891740632e-10,-0.0079375000024350488 | 0.0093052279489865761,10.92220872392207,0.030695572701401445
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.541Z | Extended Element | 5333587.2891186913,2184678.6238939422,360.99867934284845 | -89.1454 | -0.000513901 | 179.99 | -0.0093037679681664126,5.4414297567292473e-10,-0.0079375000033928226 | 0.009304035726688982,10.278598414929036,0.031175471937022237
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.554Z | Extended Element | 5333577.4766699644,2184678.4775265767,360.99418981134829 | -89.1454 | -0.0000691087 | -179.924 | -0.0093051861248605646,2.3200830417529271e-10,-0.0079375000016754932 | 0.0093051096600845519,10.922208877728341,0.030456613432449403
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.568Z | Extended Element | 5333567.6642372347,2184678.3311594501,360.9759137345215 | -89.1454 | 0.000158789 | -179.85 | -0.0093038826416660756,3.2542348486369363e-10,-0.0079375000016921188 | 0.0093038057555480703,10.463628615532722,0.030896596338463474
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.579Z | Extended Element | 5333546.9311344381,2184678.0218941788,360.89684991107413 | -89.1454 | 180 | -0.2521 | -0.0079375030186018426,-1.9818316941711285e-10,-0.0079375000003052351 | 0.0079374998429150474,10.922023886998291,0.008608361210733299
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.635Z | Extended Element | 5333598.2531805132,2184678.4951793235,360.96642041194616 | 90.8546 | 0.00028054 | 0.0839428 | -0.0093042252906187593,-8.5597774423560509,-0.0093042251999567831 | 0.0093042261152349592,1.4274969105675352,0.025205147049852491
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.651Z | Extended Element | 5333596.9995720806,2184678.4764798004,360.98415818984074 | -89.1454 | -0.0000590639 | 179.916 | -0.0093038338574156793,4.951315388576443e-10,-0.0079375000010578553 | 0.009303983114732706,10.841756726713106,0.030414573637937748
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.664Z | Extended Element | 5333587.1871262323,2184678.3301124778,360.99311784741212 | -89.1454 | 0.000398149 | 179.998 | -0.009303944110283232,-1.2654174238321987e-10,-0.0079375000000568453 | 0.009303825595303402,10.172235342825847,0.030122310143962917
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.677Z | Extended Element | 5333577.37467747,2184678.1837451132,360.98832359988529 | -89.1454 | 0.0000886523 | -179.924 | -0.0093052137999119298,-2.1959526775868136e-10,-0.0079375000019365101 | 0.0093050986504183524,10.922208787630927,0.030594015426572797
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.691Z | Extended Element | 5333567.5622448996,2184678.037377988,360.9699101210108 | -89.1454 | 0.0000845169 | -179.85 | -0.0093039189405782572,-5.2054999466527403e-10,-0.0079375000020582981 | 0.0093038113057710373,10.357265558505405,0.031056898174121307
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.703Z | Extended Element | 5333546.8291426534,2184677.7281127251,360.8906575816244 | -89.1454 | 179.999 | -0.2521 | -0.0079375062967260972,-3.3246693581167481e-11,-0.0079374999996372972 | 0.0079375001468173813,10.922023892885521,0.0085799458858552766
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.759Z | Extended Element | 5333598.1511881473,2184678.2013979675,360.96061147411308 | 90.8546 | 0.000667383 | 0.0839427 | -0.0093042259127082104,-8.5597777872909351,-0.0093042252960792923 | 0.0093042256038119095,1.3211340740272215,0.025205147170353694
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.773Z | Extended Element | 5333596.8975798273,2184678.1826983397,360.97834925184122 | -89.1454 | -0.0000860425 | 179.916 | -0.0093038787832630879,8.2369414548765583e-11,-0.0079375000024047432 | 0.0093038451826669769,10.735394001996209,0.030566914229288658
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.788Z | Extended Element | 5333587.0851337537,2184678.0363310142,360.98715656847236 | -89.1454 | 0.000105442 | 179.998 | -0.0093038748748888681,4.3523447055315213e-10,-0.0079375000013652344 | 0.009303849770525046,10.065872506551196,0.030267674615019571
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.802Z | Extended Element | 5333577.2726849765,2184677.8899636487,360.98221695688937 | -89.1454 | -0.0000629355 | -179.924 | -0.0093099675387861812,-4.1395797902764069e-10,-0.0079374999993178808 | 0.0093039404893547929,10.920373679608195,0.030208251111520847
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.813Z | Extended Element | 5333567.4602519115,2184677.7435965175,360.9639043772994 | -89.1454 | -0.0000668049 | -179.837 | -0.0093039038060722251,-2.4608891670472314e-11,-0.007937500000321434 | 0.0093038803983111623,10.250902060331216,0.029373963843430974
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.826Z | Extended Element | 5333546.7271508696,2184677.4343312723,360.88422482063595 | -89.1454 | 179.999 | -0.2521 | -0.0079375059169267178,-1.4069954046652708e-10,-0.0079374999997300546 | 0.0079375000492130487,10.922023896592545,0.0085515305629621421
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.881Z | Extended Element | 5333598.0497941691,2184677.9093405283,360.95496181204237 | 90.8546 | 0.00214299 | 0.0839427 | -0.00930422555524873,-8.5597781285645258,-0.0093042251711659973 | 0.0093042255174020146,1.2153952712592608,0.025205146806878121
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.894Z | Extended Element | 5333596.7961859656,2184677.8906404986,360.97269958960754 | -89.1454 | -0.000126029 | 179.916 | -0.0093038294722541937,-3.987385666116656e-10,-0.0079375000018422747 | 0.0093039735040303488,10.629655309231556,0.030718362031861922
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.907Z | Extended Element | 5333586.9837396657,2184677.7442731713,360.98135545908747 | -89.1454 | -0.000165548 | 179.998 | -0.0093038402315439965,-4.5450811747672387e-10,-0.0079375000015943879 | 0.0093040101843568541,9.9601337017980871,0.030412185639774651
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.918Z | Extended Element | 5333577.1712908726,2184677.5979058049,360.9762713363005 | -89.1454 | -0.000133718 | -179.924 | -0.0093038079094605458,-5.9238417829974512e-10,-0.0079375000013601812 | 0.0093039057872577012,10.814634765899839,0.03036759586040404
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.929Z | Extended Element | 5333567.3588580294,2184677.4515386773,360.95779939495594 | -89.1454 | -0.0000692635 | -179.837 | -0.0093038836676555894,4.5941439420960329e-10,-0.0079375000014989105 | 0.0093038810109091052,10.145163034746547,0.029510559331580741
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.941Z | Extended Element | 5333546.6257574726,2184677.1422734382,360.87795499539436 | -89.1454 | -180 | -0.251531 | -0.0079375001724806878,2.2448020200951711e-10,-0.0079374999996971521 | 0.0079375000663553779,10.922023827662192,0.0084148086000461388
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:04.995Z | Extended Element | 5333595.6166871749,2184677.6698230486,360.95448623105494 | -89.1454 | 0.00159124 | -0.0839427 | -0.0093042260505446211,3.0862481857997706e-10,-0.0093042251923435449 | 0.0093042253833015842,10.922230319241125,0.025205147349976115
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.009Z | Extended Element | 5333596.7252656659,2184677.6863596058,360.9687628350095 | -89.1454 | -0.000146229 | 179.916 | -0.0093038265028348201,1.7326430925805642e-10,-0.0079375000006016126 | 0.0093039006095206774,10.555696003086709,0.030824292217930274
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.023Z | Extended Element | 5333586.9128192123,2184677.5399922747,360.97731277423719 | -89.1454 | -0.000376753 | 179.998 | -0.0093038242850926427,-3.7615978328897814e-10,-0.0079375000015117336 | 0.0093040810754465714,9.8861743207730068,0.030513265184864614
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.040Z | Extended Element | 5333577.1003704034,2184677.3936249074,360.97212757257336 | -89.1454 | -0.0000947525 | -179.924 | -0.0093038305788104899,4.0682886847489475e-10,-0.0079375000003894716 | 0.0093038251418687372,10.740675305686914,0.030479062421041453
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.054Z | Extended Element | 5333567.2879377194,2184677.2472577831,360.95354416508866 | -89.1454 | -0.000104821 | -179.837 | -0.0093039107610972688,5.4707283144659015e-10,-0.007937500000795808 | 0.0093038830242586617,10.071203498280155,0.02960610111172627
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.064Z | Extended Element | 5333546.5548375007,2184676.9379925495,360.87358446557181 | -89.1454 | -180 | -0.251535 | -0.0079375002767843941,1.456221484355715e-10,-0.0079375000032705645 | 0.0079374999623605356,10.922023830128357,0.0083959277182473202
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.115Z | Extended Element | 5333595.5457669515,2184677.4655424575,360.95050599756439 | -89.1454 | 0.000521562 | -0.0839428 | -0.0093042254742485529,-2.67330247301372e-11,-0.0093042251601885978 | 0.0093042254349865981,10.922230403781787,0.025205147352407462
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.129Z | Extended Element | 5333596.6543453727,2184677.4820787124,360.9647826016315 | -89.1454 | -0.0000596452 | 179.916 | -0.00930396212636991,-2.3706937568364822e-12,-0.007937500002573393 | 0.0093038448196249707,10.481736700962591,0.030930222795909106
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.143Z | Extended Element | 5333586.8418987589,2184677.3357113777,360.97322661061122 | -89.1454 | 0.000294756 | 179.998 | -0.0093039183362712431,-3.5482088737569362e-10,-0.0079375000017278593 | 0.0093038304831246452,9.8122149396908256,0.03061434365895804
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.156Z | Extended Element | 5333577.0294499388,2184677.1893440126,360.96794033007416 | -89.1454 | -0.000130366 | -179.924 | -0.0093038080551790248,7.9354668667606444e-11,-0.0079375000028267632 | 0.0093038862080343978,10.666715846055981,0.030590528532003301
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.169Z | Extended Element | 5333567.2170174075,2184677.0429768893,360.9492454564417 | -89.1454 | -0.000184486 | -179.837 | -0.0093038646064117856,3.7255154130290656e-10,-0.0079374999986926015 | 0.0093039040245029622,9.9972439605995476,0.029701643106555715
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.180Z | Extended Element | 5333546.4839175288,2184676.7337116604,360.86917045698334 | -89.1454 | -180 | -0.25154 | -0.0079375000146140948,-3.7740022667173231e-10,-0.007937500001827474 | 0.0079375002286422476,10.922023833094181,0.0083770327495226258
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.240Z | Extended Element | 5333595.4748467319,2184677.2612616341,360.94656839975113 | -89.1454 | 0.000279566 | -0.0839428 | -0.0093042261561266312,-1.9243736090216267e-11,-0.0093042252746075322 | 0.0093042258259039296,10.922230486758981,0.025205147534115339
