Properties of the parts of a building model (IFC4X3_ADD2), part 16 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.267Z | Extended Element | 5333605.2189830961,2184679.778602967,361.00689415625754 | -179.145 | -0.0000167875 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.276Z | Extended Element | 5333605.1046959003,2184679.776898202,361.00716478795164 | -179.145 | -0.0000367001 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.286Z | Extended Element | 5333604.9904087065,2184679.7751934379,361.0074354196438 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.294Z | Extended Element | 5333604.8761215126,2184679.7734886734,361.00770605134863 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.305Z | Extended Element | 5333604.7618343187,2184679.7717839084,361.00797668304938 | -179.145 | -0.0000366428 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.313Z | Extended Element | 5333604.6475471249,2184679.7700791438,361.00824731474813 | -179.145 | -0.0000234059 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.324Z | Extended Element | 5333604.5332599301,2184679.7683743793,361.00851794643955 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.334Z | Extended Element | 5333604.4189727353,2184679.7666696147,361.00878857815235 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.343Z | Extended Element | 5333604.3046855414,2184679.7649648502,361.00905920983365 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.352Z | Extended Element | 5333604.1903983448,2184679.7632600851,361.00932984154235 | -179.145 | -0.0000168369 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.362Z | Extended Element | 5333604.0761111509,2184679.7615553197,361.00960047323463 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.372Z | Extended Element | 5333603.961823958,2184679.7598505565,361.00987110493924 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.381Z | Extended Element | 5333603.8475367632,2184679.7581457919,361.01014173664146 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.390Z | Extended Element | 5333603.7332495702,2184679.7564410269,361.01041236833566 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.401Z | Extended Element | 5333603.6189623736,2184679.7547362624,361.01068300002521 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.410Z | Extended Element | 5333603.5046751797,2184679.7530314974,361.01095363172578 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.419Z | Extended Element | 5333603.3903879868,2184679.7513267333,361.01122426345114 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.429Z | Extended Element | 5333603.2761007911,2184679.7496219678,361.0114948951275 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.438Z | Extended Element | 5333603.1618135972,2184679.7479172037,361.01176552682881 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.449Z | Extended Element | 5333603.0475264033,2184679.7462124391,361.01203615853109 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.457Z | Extended Element | 5333602.9332392076,2184679.7445076737,361.01230679023115 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.467Z | Extended Element | 5333602.8189520128,2184679.74280291,361.01257742192604 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.475Z | Extended Element | 5333602.7046648189,2184679.741098145,361.01284805362417 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.484Z | Extended Element | 5333602.5903776251,2184679.7393933805,361.01311868531894 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.492Z | Extended Element | 5333602.4760904312,2184679.7376886159,361.01338931701224 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.502Z | Extended Element | 5333602.3618032355,2184679.7359838504,361.0136599487106 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.512Z | Extended Element | 5333602.2475160416,2184679.7342790868,361.01393058041981 | -179.145 | -0.0000168289 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.521Z | Extended Element | 5333602.1332288487,2184679.7325743227,361.01420121211584 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.529Z | Extended Element | 5333602.0189416548,2184679.7308695577,361.01447184381044 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.538Z | Extended Element | 5333601.904654461,2184679.7291647932,361.01474247552522 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.548Z | Extended Element | 5333601.7903672652,2184679.7274600277,361.01501310719783 | -179.145 | -0.0000367988 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.557Z | Extended Element | 5333601.6760800704,2184679.7257552636,361.01528373891728 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.565Z | Extended Element | 5333601.5617928747,2184679.7240504981,361.01555437060489 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.573Z | Extended Element | 5333601.4475056808,2184679.722345734,361.01582500230541 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.582Z | Extended Element | 5333601.333218487,2184679.7206409699,361.01609563401962 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.591Z | Extended Element | 5333601.218931294,2184679.7189362049,361.01636626569183 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.601Z | Extended Element | 5333601.1046440983,2184679.7172314399,361.01663689739786 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.612Z | Extended Element | 5333600.9903569035,2184679.7155266758,361.01690752909741 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.619Z | Extended Element | 5333600.8760697097,2184679.7138219108,361.01717816079275 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.628Z | Extended Element | 5333600.7617825158,2184679.7121171458,361.01744879250469 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.637Z | Extended Element | 5333600.647495321,2184679.7104123817,361.017719424201 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.646Z | Extended Element | 5333600.5332081253,2184679.7087076167,361.0179900558839 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.656Z | Extended Element | 5333600.4189209333,2184679.707002853,361.01826068758805 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.665Z | Extended Element | 5333600.3046337375,2184679.7052980876,361.01853131927567 | -179.145 | -0.0000235046 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.675Z | Extended Element | 5333600.1903465427,2184679.7035933235,361.01880195098221 | -179.145 | -0.0000168289 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.685Z | Extended Element | 5333600.076059347,2184679.7018885585,361.01907258268022 | -179.145 | -0.0000367001 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.694Z | Extended Element | 5333599.9617721541,2184679.7001837939,361.01934321436892 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.704Z | Extended Element | 5333599.8474849612,2184679.6984790293,361.01961384607989 | -179.145 | -0.0000301232 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.714Z | Extended Element | 5333599.7331977682,2184679.6967742648,361.01988447777603 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.724Z | Extended Element | 5333599.6189105716,2184679.6950694998,361.02015510947513 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.734Z | Extended Element | 5333599.5046233768,2184679.6933647352,361.02042574117155 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.743Z | Extended Element | 5333599.390336182,2184679.6916599711,361.02069637287877 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.754Z | Extended Element | 5333599.27604899,2184679.6899552066,361.02096700457292 | -179.145 | -0.0000167302 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.764Z | Extended Element | 5333599.1617617942,2184679.6882504416,361.02123763627441 | -179.145 | -0.000015708 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.775Z | Extended Element | 5333599.0474746004,2184679.6865456766,361.02150826796503 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.786Z | Extended Element | 5333598.9331874065,2184679.6848409125,361.02177889966367 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.795Z | Extended Element | 5333598.8189002117,2184679.6831361474,361.02204953135123 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.806Z | Extended Element | 5333598.7046130169,2184679.6814313829,361.02232016304993 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.822Z | Extended Element | 5333598.5903256331,2184679.6797266151,361.02248811580432 | -179.145 | -0.0000290596 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.832Z | Extended Element | 5333598.4760382166,2184679.6780218473,361.02263774272581 | -179.145 | -0.0000235619 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.842Z | Extended Element | 5333598.3617507992,2184679.6763170795,361.02278736963967 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.853Z | Extended Element | 5333598.2474633856,2184679.6746123121,361.02293699656104 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.863Z | Extended Element | 5333598.1331759663,2184679.6729075438,361.0230866235035 | -179.145 | -0.0000234059 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.872Z | Extended Element | 5333598.0188885499,2184679.671202776,361.02323625040907 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.884Z | Extended Element | 5333597.9046011344,2184679.6694980073,361.02338587731782 | -179.145 | -0.0000300165 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.893Z | Extended Element | 5333597.790313717,2184679.6677932399,361.02353550425477 | -179.145 | -0.0000290516 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.903Z | Extended Element | 5333597.6760262996,2184679.6660884721,361.02368513117165 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.912Z | Extended Element | 5333597.5617388841,2184679.6643837043,361.02383475809353 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.923Z | Extended Element | 5333597.4474514667,2184679.6626789365,361.02398438504309 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.934Z | Extended Element | 5333597.3331640512,2184679.6609741678,361.02413401194531 | -179.145 | -0.0000224905 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.944Z | Extended Element | 5333597.2188766338,2184679.6592693999,361.02428363885696 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.954Z | Extended Element | 5333597.1045892145,2184679.6575646321,361.02443326578475 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.963Z | Extended Element | 5333596.990301799,2184679.6558598643,361.02458289271186 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.974Z | Extended Element | 5333596.8760143816,2184679.654155097,361.0247325196375 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.985Z | Extended Element | 5333596.7617269652,2184679.6524503292,361.02488214654431 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.993Z | Extended Element | 5333596.6474395497,2184679.6507455613,361.02503177348001 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.006Z | Extended Element | 5333596.5331521332,2184679.6490407931,361.02518140039558 | -179.145 | -0.0000158068 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.015Z | Extended Element | 5333596.4188647131,2184679.6473360253,361.02533102732843 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.025Z | Extended Element | 5333596.3045772985,2184679.6456312579,361.02548065423628 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.035Z | Extended Element | 5333596.190289882,2184679.6439264892,361.02563028115418 | -179.145 | -0.0000366428 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.044Z | Extended Element | 5333596.0760024646,2184679.6422217214,361.02577990808658 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.055Z | Extended Element | 5333595.9617150472,2184679.6405169526,361.02592953499823 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.063Z | Extended Element | 5333595.8474276327,2184679.6388121857,361.02607916193267 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.072Z | Extended Element | 5333595.7331402153,2184679.6371074175,361.0262287888375 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.081Z | Extended Element | 5333595.618852796,2184679.6354026492,361.0263784157666 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.091Z | Extended Element | 5333595.5045653814,2184679.6336978818,361.0265280426778 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.101Z | Extended Element | 5333595.3902779641,2184679.6319931131,361.02667766962031 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.109Z | Extended Element | 5333595.2759905476,2184679.6302883457,361.02682729653628 | -179.145 | -0.0000223345 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.119Z | Extended Element | 5333595.1617031312,2184679.6285835775,361.02697692345942 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.129Z | Extended Element | 5333595.0474157147,2184679.6268788096,361.02712655038493 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.139Z | Extended Element | 5333594.9331282973,2184679.6251740418,361.02727617729659 | -179.145 | -0.0000157574 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.147Z | Extended Element | 5333594.8188408809,2184679.6234692736,361.02742580420949 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.158Z | Extended Element | 5333594.7045534626,2184679.6217645057,361.02757543113853 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.166Z | Extended Element | 5333594.5902660461,2184679.6200597384,361.02772505806098 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.174Z | Extended Element | 5333594.4759786297,2184679.6183549701,361.02787468498565 | -179.145 | -0.0000168289 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.184Z | Extended Element | 5333594.3616912132,2184679.6166502018,361.02802431190071 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.193Z | Extended Element | 5333594.2474037958,2184679.6149454336,361.02817393883083 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.201Z | Extended Element | 5333594.1331163794,2184679.6132406662,361.0283235657559 | -179.145 | -0.0000223839 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.209Z | Extended Element | 5333594.0188289629,2184679.6115358979,361.02847319266544 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.218Z | Extended Element | 5333593.9045415446,2184679.6098311301,361.0286228195892 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.228Z | Extended Element | 5333593.7902541291,2184679.6081263619,361.02877244650841 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.237Z | Extended Element | 5333593.6759667136,2184679.606421594,361.02892207343353 | -179.145 | -0.000015716 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.246Z | Extended Element | 5333593.5616792953,2184679.6047168267,361.02907170036144 | -179.145 | -0.0000235046 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.257Z | Extended Element | 5333593.447391877,2184679.6030120584,361.02922132727514 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.265Z | Extended Element | 5333593.3331044624,2184679.6013072915,361.02937095420754 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.275Z | Extended Element | 5333593.218817044,2184679.5996025237,361.02952058111185 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.284Z | Extended Element | 5333593.1045296285,2184679.597897755,361.02967020803976 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.292Z | Extended Element | 5333592.9902422102,2184679.5961929872,361.02981983496795 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.304Z | Extended Element | 5333592.8759547975,2184679.5944882194,361.02996946187244 | -179.145 | -0.0000157574 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.312Z | Extended Element | 5333592.7616673764,2184679.5927834511,361.0301190888049 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.323Z | Extended Element | 5333592.6473799618,2184679.5910786837,361.03026871573337 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.334Z | Extended Element | 5333592.5330925463,2184679.589373915,361.03041834264275 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.343Z | Extended Element | 5333592.4188051289,2184679.5876691472,361.03056796955741 | -179.145 | -0.0000235619 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.353Z | Extended Element | 5333592.3045177097,2184679.5859643784,361.03071759648884 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.362Z | Extended Element | 5333592.1902302932,2184679.5842596116,361.03086722340947 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.372Z | Extended Element | 5333592.0759428777,2184679.5825548437,361.03101685032885 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.382Z | Extended Element | 5333591.9616554603,2184679.5808500755,361.03116647725381 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.391Z | Extended Element | 5333591.8473680438,2184679.5791453077,361.03131610417626 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.402Z | Extended Element | 5333591.7330806274,2184679.5774405389,361.03146573109728 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.410Z | Extended Element | 5333591.6187932128,2184679.575735772,361.03161535802252 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.421Z | Extended Element | 5333591.5045057917,2184679.5740310038,361.03176498494452 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.430Z | Extended Element | 5333591.3902183762,2184679.5723262359,361.03191461185878 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.440Z | Extended Element | 5333591.2759309607,2184679.5706214681,361.03206423879396 | -179.145 | -0.0000290102 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.456Z | Extended Element | 5333591.1616435125,2184679.5689166998,361.03217641754497 | -179.145 | -0.0000168289 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.466Z | Extended Element | 5333591.047356003,2184679.5672119297,361.03220507918849 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.475Z | Extended Element | 5333590.9330684915,2184679.565507161,361.03223374085957 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.486Z | Extended Element | 5333590.8187809801,2184679.5638023918,361.03226240250808 | -179.145 | -0.0000301724 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.494Z | Extended Element | 5333590.7044934686,2184679.5620976221,361.03229106417405 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.506Z | Extended Element | 5333590.5902059572,2184679.5603928524,361.03231972583592 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.517Z | Extended Element | 5333590.4759184457,2184679.5586880832,361.03234838748841 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.526Z | Extended Element | 5333590.3616309352,2184679.5569833145,361.03237704916387 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.536Z | Extended Element | 5333590.2473434256,2184679.5552785448,361.03240571082017 | -179.145 | -0.0000367988 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.545Z | Extended Element | 5333590.1330559142,2184679.5535737756,361.0324343724775 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.556Z | Extended Element | 5333590.0187684037,2184679.5518690064,361.03246303413943 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.566Z | Extended Element | 5333589.9044808913,2184679.5501642362,361.03249169579328 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.575Z | Extended Element | 5333589.7901933817,2184679.5484594675,361.03252035743913 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.582Z | Extended Element | 5333589.6759058693,2184679.5467546983,361.03254901912004 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.590Z | Extended Element | 5333589.5616183579,2184679.5450499281,361.03257768076168 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.598Z | Extended Element | 5333589.4473308474,2184679.5433451589,361.03260634243577 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.607Z | Extended Element | 5333589.3330433359,2184679.5416403897,361.03263500409497 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.616Z | Extended Element | 5333589.2187558236,2184679.5399356205,361.03266366576014 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.627Z | Extended Element | 5333589.1044683149,2184679.5382308508,361.03269232741849 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.636Z | Extended Element | 5333588.9901808007,2184679.5365260812,361.03272098907212 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.645Z | Extended Element | 5333588.8758932929,2184679.5348213124,361.03274965073257 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.654Z | Extended Element | 5333588.7616057806,2184679.5331165432,361.0327783123933 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.662Z | Extended Element | 5333588.6473182682,2184679.531411774,361.03280697405756 | -179.145 | -0.0000367001 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.672Z | Extended Element | 5333588.5330307567,2184679.5297070048,361.03283563570892 | -179.145 | -0.0000300659 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.680Z | Extended Element | 5333588.4187432453,2184679.5280022346,361.0328642973659 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.691Z | Extended Element | 5333588.3044557348,2184679.526297465,361.0328929590338 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.701Z | Extended Element | 5333588.1901682261,2184679.5245926967,361.03292162069084 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.710Z | Extended Element | 5333588.0758807147,2184679.522887927,361.03295028235601 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.721Z | Extended Element | 5333587.9615932014,2184679.5211831578,361.03297894400276 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.730Z | Extended Element | 5333587.8473056927,2184679.5194783886,361.03300760566259 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.740Z | Extended Element | 5333587.7330181804,2184679.5177736189,361.03303626734083 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.751Z | Extended Element | 5333587.618730668,2184679.5160688492,361.03306492898912 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.760Z | Extended Element | 5333587.5044431575,2184679.51436408,361.03309359064195 | -179.145 | -0.0000367988 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.772Z | Extended Element | 5333587.390155647,2184679.5126593113,361.03312225231991 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.781Z | Extended Element | 5333587.2758681364,2184679.5109545421,361.03315091395046 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.793Z | Extended Element | 5333587.1615806259,2184679.5092497724,361.03317957561484 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.804Z | Extended Element | 5333587.0472931126,2184679.5075450027,361.03320823728092 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.816Z | Extended Element | 5333586.933005603,2184679.5058402335,361.03323689895342 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.825Z | Extended Element | 5333586.8187180897,2184679.5041354639,361.03326556060119 | -179.145 | -0.0000168369 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.835Z | Extended Element | 5333586.7044305792,2184679.5024306951,361.03329422226517 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.844Z | Extended Element | 5333586.5901430696,2184679.5007259254,361.03332288392369 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.855Z | Extended Element | 5333586.4758555591,2184679.4990211558,361.0333515455817 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.863Z | Extended Element | 5333586.3615680458,2184679.4973163856,361.03338020724851 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.875Z | Extended Element | 5333586.2472805353,2184679.4956116169,361.03340886889839 | -179.145 | -0.0000168369 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.885Z | Extended Element | 5333586.1329930238,2184679.4939068481,361.03343753055873 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.895Z | Extended Element | 5333586.0187055133,2184679.4922020789,361.03346619223015 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.905Z | Extended Element | 5333585.9044180028,2184679.4904973092,361.03349485387321 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.915Z | Extended Element | 5333585.7901304904,2184679.4887925405,361.03352351554264 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.926Z | Extended Element | 5333585.6758429818,2184679.4870877708,361.03355217721463 | -179.145 | -0.0000224411 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.937Z | Extended Element | 5333585.5615554685,2184679.4853830012,361.03358083885411 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.946Z | Extended Element | 5333585.4472679561,2184679.4836782319,361.03360950051524 | -179.145 | -0.0000167302 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.957Z | Extended Element | 5333585.3329804465,2184679.4819734627,361.0336381621679 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.968Z | Extended Element | 5333585.218692936,2184679.4802686935,361.0336668238499 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.978Z | Extended Element | 5333585.1044054255,2184679.4785639239,361.0336954855108 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:43.989Z | Extended Element | 5333584.990117914,2184679.4768591551,361.03372414715005 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.002Z | Extended Element | 5333584.8758304026,2184679.4751543854,361.03375280881306 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.011Z | Extended Element | 5333584.7615428912,2184679.4734496158,361.03378147047584 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.022Z | Extended Element | 5333584.6472553806,2184679.4717448461,361.03381013214931 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.030Z | Extended Element | 5333584.5329678701,2184679.4700400773,361.03383879380709 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.038Z | Extended Element | 5333584.4186803587,2184679.4683353081,361.03386745544844 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.046Z | Extended Element | 5333584.3043928472,2184679.4666305394,361.03389611712367 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.058Z | Extended Element | 5333584.1901053367,2184679.4649257688,361.03392477878111 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.068Z | Extended Element | 5333584.0758178262,2184679.4632209991,361.03395344042178 | -179.145 | -0.0000224332 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
