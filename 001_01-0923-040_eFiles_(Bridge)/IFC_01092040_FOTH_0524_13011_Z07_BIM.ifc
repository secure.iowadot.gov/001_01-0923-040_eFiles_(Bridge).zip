Properties of the parts of a building model (IFC4X3_ADD2), part 13 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.298Z | Extended Element | 5333607.2393267723,2184679.8754227371,360.91387971995107 | 0.854593 | 180 | -1.14577 | -0.010875817392592005,-2.2776447885132148e-11,-0.010735101104177545 | 0.010877131068383755,11.223721951101199,0.28632828606770083
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.322Z | Extended Element | 5333607.5069522932,2184680.6669039386,360.92878781257008 | 0.854593 | 180 | -1.14577 | -0.010875772592444873,1.3044971308116855e-10,-0.010735100986237799 | 0.010877183948980129,10.43616291052729,0.28632829211949767
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.347Z | Extended Element | 5333607.7749566548,2184681.4329879158,360.94313735384429 | 0.854592 | 180 | -1.14577 | -0.010874410864501131,-3.0704328934535439e-11,-0.010735092346376447 | 0.010878535587647353,9.6740090018268923,0.28632829378619701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.371Z | Extended Element | 5333608.0429610144,2184682.1990718916,360.9574868953145 | 0.854602 | 179.999 | -1.14577 | -0.010875657132230925,1.5618586493895799e-10,-0.01073510089033374 | 0.010877299431755734,8.9118550923929938,0.28632829813031707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.397Z | Extended Element | 5333608.1893585939,2184691.1176652703,360.8580453205559 | -179.145 | 0.00000231262 | -0.00000804569 | -0.01087459929277544,-7.1880248241631464e-10,-0.010874635521914332 | 0.010874601343573733,8.1536067572919926,0.13622235141211628
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.419Z | Extended Element | 5333608.4687280739,2184691.1218324839,360.85715472679692 | -179.145 | 0.00000221123 | -0.00000302362 | -0.010874593828579601,-9.3397835466775415e-11,-0.010874591195494233 | 0.010874595084307161,7.391478438779246,0.13622155618796733
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.444Z | Extended Element | 5333608.7480975501,2184691.1259996989,360.85626413341646 | -179.145 | 0.00000226192 | -0.0000080457 | -0.010874600384511292,-6.0429733981671261e-10,-0.010874634189391648 | 0.010874598735401825,6.6041233801982848,0.1319891653614999
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.470Z | Extended Element | 5333609.1145996153,2184685.2888050326,360.96353453703927 | 0.854588 | -0.00000696573 | -1.14575 | -0.010874597247688788,1.7354548692235697e-10,-0.010874596813858635 | 0.010874592959901853,5.8431977456923043,0.018157384288883339
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.494Z | Extended Element | 5333609.3826039806,2184686.0548890126,360.94734386143966 | 0.854588 | -0.00000148835 | -1.14575 | -0.01087459622718436,-1.8943694161411381e-10,-0.010874596833534467 | 0.010874594859653875,5.0810438358832934,0.018157384279561189
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.520Z | Extended Element | 5333609.6506083431,2184686.820972994,360.93115318541925 | 0.854588 | -0.00000761008 | -1.14576 | -0.010874595254226654,-3.3245098921601715e-12,-0.010874598151999803 | 0.010874596945760092,4.318889926335868,0.018157382968859215
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.546Z | Extended Element | 5333609.9182338687,2184687.6124542002,360.9144545113212 | 0.854588 | -0.00000782823 | -1.14576 | -0.01087459821425356,1.828671606738691e-10,-0.010874596881016043 | 0.010874593975952735,3.5313308872155518,0.018157384039999277
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.570Z | Extended Element | 5333610.1862382302,2184688.3785381764,360.89826383504538 | 0.854588 | -0.00000229676 | -1.14576 | -0.010874596170358727,8.7767489468824299e-11,-0.010874598155025478 | 0.010874596034873608,2.769176978577859,0.018157382553247742
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.595Z | Extended Element | 5333610.4542425917,2184689.1446221541,360.88205808153833 | 0.854588 | -2.95201e-07 | -1.14576 | -0.010874593058198236,5.8559116115877647e-12,-0.010874557774501014 | 0.010874594070509856,2.0070230713789181,0.018157430357451914
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.620Z | Extended Element | 5333610.7222469663,2184689.9107061457,360.86580725399324 | 0.854588 | -0.0000109141 | -1.14576 | -0.010874592773915304,-4.6018408698425089e-10,-0.010874557790005972 | 0.010874594367300797,1.2448691616180334,0.018157439037768171
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.646Z | Extended Element | 5333610.9830534197,2184691.1593374065,360.84854048280738 | -179.145 | 0.0000314671 | -0.00000804253 | -0.010874593933538483,1.6627826438262485e-10,-0.010874592465204381 | 0.010874596349969108,0.48279142693784155,0.010886019589927274
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.656Z | Complex Chain | 5333550.9679298215,2184690.2545966236,360.89985126313331 | 0 | 0 | 0 | 0,-2.9714753902517259,-5.8314356010669144e-08 | 0.044323965907096863,0,0.050990176664640785
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.666Z | Complex Chain | 5333550.9679298364,2184690.2545958785,360.89985126069166 | 0 | 0 | 0 | 0,0,0 | 60.097718765027821,0.89644745923578739,0.083478350462831613
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.698Z | Extended Element | 5333551.1178804021,2184687.2846968123,360.9513062486082 | 0.854589 | 0.000022843 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.715Z | Extended Element | 5333551.2321668025,2184687.2864015647,360.9518053179537 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.724Z | Extended Element | 5333551.3464532299,2184687.2881063186,360.95229830458061 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.734Z | Extended Element | 5333551.4607396545,2184687.2898110705,360.95279129119626 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.743Z | Extended Element | 5333551.5750260809,2184687.2915158244,360.95328427780038 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.752Z | Extended Element | 5333551.6893125065,2184687.2932205782,360.95377726442649 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.761Z | Extended Element | 5333551.803598932,2184687.2949253307,360.95427025103021 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.770Z | Extended Element | 5333551.9178853612,2184687.2966300836,360.95476323766286 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.782Z | Extended Element | 5333552.0321717858,2184687.2983348374,360.95525622427704 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.791Z | Extended Element | 5333552.1464582123,2184687.3000395903,360.95574921090156 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.801Z | Extended Element | 5333552.2607446387,2184687.3017443428,360.95624219750368 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.814Z | Extended Element | 5333552.3750310643,2184687.3034490962,360.95673518413736 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.822Z | Extended Element | 5333552.4893174907,2184687.30515385,360.95722817073903 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.833Z | Extended Element | 5333552.60360392,2184687.3068586029,360.95772115736594 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.841Z | Extended Element | 5333552.7178903446,2184687.3085633563,360.95821414397187 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.852Z | Extended Element | 5333552.8321767701,2184687.3102681092,360.95870713060765 | 0.854589 | 0.0000219276 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.862Z | Extended Element | 5333552.9464631937,2184687.3119728621,360.9592001172079 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.872Z | Extended Element | 5333553.060749623,2184687.313677615,360.95969310383418 | 0.854589 | 0.0000231059 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.883Z | Extended Element | 5333553.1750360504,2184687.3153823675,360.96018609045456 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.891Z | Extended Element | 5333553.289322475,2184687.3170871218,360.96067907705481 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.902Z | Extended Element | 5333553.4036089014,2184687.3187918756,360.9611720636824 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.912Z | Extended Element | 5333553.5178953279,2184687.3204966285,360.96166505029197 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.923Z | Extended Element | 5333553.6321817553,2184687.3222013805,360.96215803692235 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.935Z | Extended Element | 5333553.7464681799,2184687.3239061339,360.9626510235351 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.945Z | Extended Element | 5333553.8607546072,2184687.3256108873,360.96314401015564 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.954Z | Extended Element | 5333553.9750410318,2184687.3273156402,360.96363699677858 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.965Z | Extended Element | 5333554.0893274583,2184687.3290203935,360.96412998337814 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.974Z | Extended Element | 5333554.2036138866,2184687.3307251469,360.96462297000653 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.984Z | Extended Element | 5333554.3179003121,2184687.3324298998,360.96511595661315 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.994Z | Extended Element | 5333554.4321867386,2184687.3341346537,360.96560894323807 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.005Z | Extended Element | 5333554.5464731632,2184687.3358394057,360.96610192985594 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.016Z | Extended Element | 5333554.6607595915,2184687.337544159,360.96659491646852 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.027Z | Extended Element | 5333554.775046018,2184687.3392489124,360.96708790309987 | 0.854589 | 0.0000218288 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.036Z | Extended Element | 5333554.8893324435,2184687.3409536649,360.9675808897174 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.048Z | Extended Element | 5333555.0036188718,2184687.3426584192,360.96807387631139 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.057Z | Extended Element | 5333555.1179052964,2184687.3443631725,360.96856686293989 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.068Z | Extended Element | 5333555.2321917219,2184687.346067925,360.96905984956305 | 0.854589 | 0.0000295683 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.077Z | Extended Element | 5333555.3464781465,2184687.3477726779,360.9695528361728 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.085Z | Extended Element | 5333555.460764573,2184687.3494774313,360.97004582277646 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.094Z | Extended Element | 5333555.5750510013,2184687.3511821846,360.97053880940774 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.103Z | Extended Element | 5333555.6893374259,2184687.3528869376,360.97103179603141 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.113Z | Extended Element | 5333555.8036238551,2184687.3545916909,360.97152478265372 | 0.854589 | 0.0000153666 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.122Z | Extended Element | 5333555.9179102806,2184687.3562964443,360.97201776926363 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.135Z | Extended Element | 5333556.0321967062,2184687.3580011968,360.97251075587883 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.145Z | Extended Element | 5333556.1464831326,2184687.3597059501,360.97300374249858 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.153Z | Extended Element | 5333556.2607695591,2184687.361410703,360.97349672910036 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.162Z | Extended Element | 5333556.3750559855,2184687.3631154564,360.97398971574 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.172Z | Extended Element | 5333556.489342411,2184687.3648202093,360.97448270235259 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.182Z | Extended Element | 5333556.6036288375,2184687.3665249627,360.97497568896983 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.192Z | Extended Element | 5333556.717915263,2184687.3682297161,360.9754686755727 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.201Z | Extended Element | 5333556.8322016886,2184687.3699344681,360.97596166220205 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.211Z | Extended Element | 5333556.9464881169,2184687.3716392224,360.9764546488222 | 0.854589 | 0.000022991 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.221Z | Extended Element | 5333557.0607745433,2184687.3733439753,360.97694763543382 | 0.854589 | 0.0000153091 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.237Z | Extended Element | 5333557.1750612967,2184687.3750487333,360.97735673063573 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.247Z | Extended Element | 5333557.2893480901,2184687.3767534923,360.97775520177896 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.257Z | Extended Element | 5333557.4036348844,2184687.3784582508,360.97815367294226 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.268Z | Extended Element | 5333557.5179216806,2184687.3801630097,360.9785521440956 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.277Z | Extended Element | 5333557.6322084758,2184687.3818677682,360.97895061525088 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.285Z | Extended Element | 5333557.7464952692,2184687.3835725272,360.97934908640644 | 0.854589 | 0.0000163807 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.296Z | Extended Element | 5333557.8607820664,2184687.3852772848,360.97974755755143 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.305Z | Extended Element | 5333557.9750688588,2184687.3869820442,360.98014602870307 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.316Z | Extended Element | 5333558.089355655,2184687.3886868027,360.98054449985977 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.327Z | Extended Element | 5333558.2036424484,2184687.3903915607,360.98094297101238 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.336Z | Extended Element | 5333558.3179292437,2184687.3920963192,360.98134144217278 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.346Z | Extended Element | 5333558.432216038,2184687.3938010782,360.98173991332544 | 0.854589 | 0.0000295601 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.356Z | Extended Element | 5333558.5465028351,2184687.3955058376,360.98213838448237 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.367Z | Extended Element | 5333558.6607896304,2184687.3972105961,360.9825368556223 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.377Z | Extended Element | 5333558.7750764228,2184687.3989153551,360.98293532678758 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.387Z | Extended Element | 5333558.889363219,2184687.4006201136,360.9833337979353 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.400Z | Extended Element | 5333559.0036500134,2184687.4023248721,360.98373226910178 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.409Z | Extended Element | 5333559.1179368095,2184687.4040296301,360.98413074025751 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.419Z | Extended Element | 5333559.2322236029,2184687.4057343891,360.98452921141023 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.430Z | Extended Element | 5333559.3465103973,2184687.4074391481,360.98492768256216 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.440Z | Extended Element | 5333559.4607971925,2184687.4091439079,360.98532615370766 | 0.854589 | 0.0000163807 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.451Z | Extended Element | 5333559.5750839878,2184687.4108486664,360.98572462486356 | 0.854589 | 0.000022991 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.463Z | Extended Element | 5333559.689370783,2184687.4125534245,360.98612309600787 | 0.854589 | 0.0000295683 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.471Z | Extended Element | 5333559.8036575774,2184687.4142581834,360.9865215671677 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.483Z | Extended Element | 5333559.9179443717,2184687.4159629415,360.98692003832957 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.492Z | Extended Element | 5333560.032231166,2184687.4176677004,360.98731850949088 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.503Z | Extended Element | 5333560.1465179613,2184687.4193724594,360.98771698063746 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.513Z | Extended Element | 5333560.2608047575,2184687.4210772174,360.98811545179552 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.524Z | Extended Element | 5333560.3750915509,2184687.4227819764,360.9885139229321 | 0.854589 | 0.0000219196 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.534Z | Extended Element | 5333560.4893783461,2184687.4244867349,360.98891239409312 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.545Z | Extended Element | 5333560.6036651395,2184687.4261914934,360.98931086524487 | 0.854589 | 0.0000295108 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.553Z | Extended Element | 5333560.7179519339,2184687.4278962524,360.98970933640612 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.567Z | Extended Element | 5333560.83223873,2184687.4296010109,360.99010780755856 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.576Z | Extended Element | 5333560.9465255244,2184687.4313057694,360.99050627871259 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.588Z | Extended Element | 5333561.0608123196,2184687.4330105279,360.99090474986906 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.598Z | Extended Element | 5333561.1750991149,2184687.4347152868,360.99130322102974 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.607Z | Extended Element | 5333561.2893859092,2184687.4364200453,360.991701692167 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.618Z | Extended Element | 5333561.4036727026,2184687.4381248048,360.99210016333433 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.629Z | Extended Element | 5333561.5179595007,2184687.4398295633,360.99249863447471 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.639Z | Extended Element | 5333561.632246295,2184687.4415343222,360.99289710564858 | 0.854589 | 0.0000219277 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.654Z | Extended Element | 5333561.7465330884,2184687.4432390803,360.99329557677936 | 0.854589 | 0.00001643 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.665Z | Extended Element | 5333561.8608198836,2184687.4449438392,360.99369404792924 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.674Z | Extended Element | 5333561.9751066789,2184687.4466485977,360.9940925190985 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.686Z | Extended Element | 5333562.0893934742,2184687.4483533567,360.9944909902494 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.697Z | Extended Element | 5333562.2036802666,2184687.4500581152,360.99488946140281 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.707Z | Extended Element | 5333562.3179670619,2184687.4517628741,360.99528793256457 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.717Z | Extended Element | 5333562.4322538581,2184687.4534676326,360.99568640371911 | 0.854589 | 0.0000295601 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.727Z | Extended Element | 5333562.5465406524,2184687.4551723916,360.99608487485114 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.736Z | Extended Element | 5333562.6608274467,2184687.4568771496,360.9964833460063 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.744Z | Extended Element | 5333562.775114242,2184687.4585819086,360.99688181716959 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.752Z | Extended Element | 5333562.8894010363,2184687.4602866666,360.99728028831851 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.761Z | Extended Element | 5333563.0036878334,2184687.4619914251,360.99767875948226 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.771Z | Extended Element | 5333563.1179746268,2184687.4636961846,360.99807723063179 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.780Z | Extended Element | 5333563.2322614221,2184687.4654009426,360.99847570177513 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.789Z | Extended Element | 5333563.3465482155,2184687.4671057025,360.99887417293803 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.801Z | Extended Element | 5333563.4608350126,2184687.4688104605,360.99927264408842 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.812Z | Extended Element | 5333563.575121806,2184687.470515219,360.99967111525569 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.821Z | Extended Element | 5333563.6894086003,2184687.472219978,361.00006958640131 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.832Z | Extended Element | 5333563.8036953956,2184687.473924737,361.00046805754954 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.841Z | Extended Element | 5333563.9179821908,2184687.475629495,361.00086652872295 | 0.854589 | 0.0000218288 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.852Z | Extended Element | 5333564.0322689842,2184687.4773342544,361.00126499986538 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.862Z | Extended Element | 5333564.1465557804,2184687.4790390125,361.00166347101958 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.872Z | Extended Element | 5333564.2608425748,2184687.4807437714,361.00206194216497 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.883Z | Extended Element | 5333564.37512937,2184687.4824485304,361.00246041332383 | 0.854589 | 0.0000153011 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.896Z | Extended Element | 5333564.4894161643,2184687.4841532898,361.00285888447775 | 0.854589 | 0.0000230485 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.905Z | Extended Element | 5333564.6037029605,2184687.4858580474,361.00325735563985 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.921Z | Extended Element | 5333564.717989794,2184687.4875628063,361.00364171860656 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.935Z | Extended Element | 5333564.8322769562,2184687.4892675709,361.00391595130299 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.946Z | Extended Element | 5333564.9465641165,2184687.490972335,361.00419018400248 | 0.854589 | 0.0000152105 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.955Z | Extended Element | 5333565.0608512769,2184687.4926770991,361.00446441668799 | 0.854589 | 0.0000294694 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.964Z | Extended Element | 5333565.1751384372,2184687.4943818627,361.00473864939585 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.972Z | Extended Element | 5333565.2894255985,2184687.4960866268,361.00501288209051 | 0.854589 | 0.0000229084 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.981Z | Extended Element | 5333565.4037127588,2184687.4977913918,361.00528711479222 | 0.854589 | 0.0000162739 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:37.990Z | Extended Element | 5333565.5179999182,2184687.499496155,361.00556134747711 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.000Z | Extended Element | 5333565.6322870795,2184687.5012009204,361.00583558017695 | 0.854589 | 0.0000152105 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.009Z | Extended Element | 5333565.7465742389,2184687.5029056845,361.00610981285303 | 0.854589 | 0.0000218288 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.021Z | Extended Element | 5333565.8608614001,2184687.5046104472,361.00638404556747 | 0.854589 | 0.0000295763 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.032Z | Extended Element | 5333565.9751485595,2184687.5063152118,361.00665827826504 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.042Z | Extended Element | 5333566.0894357199,2184687.5080199759,361.00693251096618 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.054Z | Extended Element | 5333566.2037228802,2184687.5097247409,361.00720674365601 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.064Z | Extended Element | 5333566.3180100396,2184687.511429504,361.00748097635773 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.073Z | Extended Element | 5333566.4322972018,2184687.5131342686,361.00775520905796 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.081Z | Extended Element | 5333566.5465843612,2184687.5148390322,361.00802944174688 | 0.854589 | 0.0000295763 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.091Z | Extended Element | 5333566.6608715216,2184687.5165437958,361.00830367444706 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.100Z | Extended Element | 5333566.7751586819,2184687.5182485604,361.0085779071407 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.110Z | Extended Element | 5333566.8894458432,2184687.5199533249,361.00885213985032 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.119Z | Extended Element | 5333567.0037330035,2184687.521658089,361.0091263725372 | 0.854589 | 0.0000162739 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.129Z | Extended Element | 5333567.1180201638,2184687.5233628536,361.00940060522987 | 0.854589 | 0.0000162739 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.140Z | Extended Element | 5333567.2323073233,2184687.5250676172,361.00967483794068 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.151Z | Extended Element | 5333567.3465944845,2184687.5267723808,361.00994907061971 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.160Z | Extended Element | 5333567.4608816449,2184687.5284771444,361.01022330331915 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.170Z | Extended Element | 5333567.5751688052,2184687.5301819094,361.0104975360191 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.178Z | Extended Element | 5333567.6894559655,2184687.531886674,361.01077176870768 | 0.854589 | 0.000022843 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.187Z | Extended Element | 5333567.803743124,2184687.5335914362,361.01104600141235 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.196Z | Extended Element | 5333567.9180302862,2184687.5352962012,361.01132023411355 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.206Z | Extended Element | 5333568.0323174493,2184687.5370009658,361.01159446680867 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.217Z | Extended Element | 5333568.1466046069,2184687.5387057299,361.01186869949532 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.228Z | Extended Element | 5333568.2608917682,2184687.540410494,361.01214293218754 | 0.854589 | 0.0000295763 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.236Z | Extended Element | 5333568.3751789276,2184687.5421152581,361.01241716489966 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.246Z | Extended Element | 5333568.489466087,2184687.5438200221,361.01269139758023 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.255Z | Extended Element | 5333568.6037532482,2184687.5455247858,361.0129656302924 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.266Z | Extended Element | 5333568.7180404086,2184687.5472295503,361.01323986298468 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.275Z | Extended Element | 5333568.8323275689,2184687.5489343139,361.01351409567542 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.287Z | Extended Element | 5333568.9466147302,2184687.550639078,361.01378832837185 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.298Z | Extended Element | 5333569.0609018896,2184687.5523438426,361.01406256106628 | 0.854589 | 0.0000296175 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.307Z | Extended Element | 5333569.1751890499,2184687.5540486071,361.01433679376174 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.317Z | Extended Element | 5333569.2894762121,2184687.5557533707,361.01461102646641 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.328Z | Extended Element | 5333569.4037633715,2184687.5574581358,361.01488525915136 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.337Z | Extended Element | 5333569.5180505291,2184687.5591628994,361.01515949186432 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.349Z | Extended Element | 5333569.6323376931,2184687.5608676639,361.01543372455961 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.357Z | Extended Element | 5333569.7466248535,2184687.5625724276,361.01570795723592 | 0.854589 | 0.0000218783 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.369Z | Extended Element | 5333569.8609120138,2184687.5642771921,361.01598218993342 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.380Z | Extended Element | 5333569.9751991732,2184687.5659819557,361.01625642263667 | 0.854589 | 0.000022843 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.390Z | Extended Element | 5333570.0894863326,2184687.5676867194,361.0165306553389 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.401Z | Extended Element | 5333570.2037734929,2184687.5693914839,361.01680488803834 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.411Z | Extended Element | 5333570.3180606551,2184687.571096248,361.01707912072703 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.421Z | Extended Element | 5333570.4323478136,2184687.5728010111,361.01735335343449 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
