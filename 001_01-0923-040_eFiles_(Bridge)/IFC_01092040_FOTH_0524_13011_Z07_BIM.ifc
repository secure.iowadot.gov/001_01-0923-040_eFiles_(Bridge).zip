Properties of the parts of a building model (IFC4X3_ADD2), part 28 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.977Z | Complex Chain | 5333607.2014680542,2184678.5975224208,360.3733222980203 | 0 | 0 | 0 | -1.0722831450402737,0,0 | 3.1215440932097493e-07,0.37226350931450725,0.29686437971344048
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.989Z | Complex Chain | 5333607.3156710295,2184678.9264764278,360.67591149732834 | 0 | 0 | 0 | -0.56838596425950527,-3.2596290111541748e-09,-0.60166551019715919 | 0,0.19732568506151438,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.998Z | Complex Chain | 5333607.3213978019,2184678.9429730973,360.37933556136045 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1122308674635946e-07,0.37226350838318467,0.29686437971884061
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.009Z | Complex Chain | 5333607.4356007753,2184679.2719271053,360.68192476112989 | 0 | 0 | 0 | -0.56838596612215042,-2.7939677238464355e-09,-0.6016655101987507 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.022Z | Complex Chain | 5333607.4413275477,2184679.2884237738,360.38534882516109 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1029176415786619e-07,0.37226350978016853,0.29686437971889745
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.031Z | Complex Chain | 5333607.5605563661,2184679.6318544359,360.68819001992409 | 0 | 0 | 0 | -0.56838596612215042,-3.7252902984619141e-09,-0.60166551019642023 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.043Z | Complex Chain | 5333607.5662831385,2184679.6483511045,360.3916140839562 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.0919909477233887e-07,0.37226350978016853,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.054Z | Complex Chain | 5333607.685511956,2184679.9917817656,360.69445527875922 | 0 | 0 | 0 | -0.56838596798479557,-3.7252902984619141e-09,-0.60166551019681813 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.064Z | Complex Chain | 5333607.810467585,2184680.3517091093,360.70072056469297 | 0 | 0 | 0 | -0.56838596519082785,-3.2596290111541748e-09,-0.60166551019573811 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.075Z | Complex Chain | 5333607.8161943564,2184680.3682057774,360.4041446287269 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1122308674635946e-07,0.37226351024582982,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.087Z | Complex Chain | 5333607.9303973243,2184680.6971598705,360.70673380359051 | 0 | 0 | 0 | -0.568385967053473,-3.7252902984619141e-09,-0.60166551019738657 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.096Z | Complex Chain | 5333607.9361240948,2184680.7136565382,360.41015786762352 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1122308674635946e-07,0.37226350978016853,0.29686437971889745
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.107Z | Complex Chain | 5333608.0503270701,2184681.0426105475,360.712747068216 | 0 | 0 | 0 | -0.56838596798479557,-3.7252902984619141e-09,-0.60166551019732972 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.117Z | Complex Chain | 5333608.0560538415,2184681.0591072161,360.41617113224811 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1013041734695435e-07,0.37226350838318467,0.29686437971707846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.126Z | Complex Chain | 5333608.1702568149,2184681.3880612236,360.7187603311192 | 0 | 0 | 0 | -0.56838596612215042,-3.7252902984619141e-09,-0.6016655101945444 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.137Z | Complex Chain | 5333608.1759835863,2184681.4045578921,360.42218439515403 | 0 | 0 | 0 | -1.0722831450402737,0,0 | 3.1029176417174398e-07,0.37226350931450725,0.29686437971707846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.146Z | Complex Chain | 5333608.2901865598,2184681.7335119005,360.72477359444298 | 0 | 0 | 0 | -0.56838596612215042,-3.7252902984619141e-09,-0.60166551019687498 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.157Z | Complex Chain | 5333608.2959133312,2184681.7500085682,360.4281976584769 | 0 | 0 | 0 | -1.0722831441089511,0,0 | 3.1122308674635946e-07,0.37226350931450725,0.29686437971616897
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.166Z | Complex Chain | 5333608.4151421515,2184682.0934392298,360.73103885346791 | 0 | 0 | 0 | -0.56838596612215042,-3.2596290111541748e-09,-0.60166551019704551 | 0,0.19732568459585309,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.175Z | Complex Chain | 5333608.4208689239,2184682.1099358988,360.43446291750001 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1029176415786619e-07,0.37226350931450725,0.29686437971889745
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.185Z | Complex Chain | 5333608.5400977414,2184682.4533665609,360.73730411223124 | 0 | 0 | 0 | -0.568385967053473,-4.1909515857696533e-09,-0.60166551019880765 | 0,0.19732568459585309,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.195Z | Complex Chain | 5333608.6650533313,2184682.813293891,360.74356937042774 | 0 | 0 | 0 | -0.568385967053473,-3.2596290111541748e-09,-0.60166551019823922 | 0,0.19732568552717566,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.206Z | Complex Chain | 5333608.6707801027,2184682.8297905596,360.44699343445984 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1122308673248167e-07,0.37226350978016853,0.29686437971707846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.217Z | Complex Chain | 5333608.7849830771,2184683.1587445689,360.74958263474258 | 0 | 0 | 0 | -0.56838596798479557,-3.7252902984619141e-09,-0.60166551019596548 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.227Z | Complex Chain | 5333608.7907098467,2184683.175241237,360.45300669877741 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1013041734695435e-07,0.37226350978016853,0.29686437971793112
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.241Z | Complex Chain | 5333608.9049128229,2184683.5041952468,360.75559589794642 | 0 | 0 | 0 | -0.56838596612215042,-4.1909515857696533e-09,-0.60166551019829606 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.252Z | Complex Chain | 5333608.9106395952,2184683.5206919154,360.45901996197944 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1106173992156982e-07,0.37226350978016853,0.29686437971707846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.262Z | Complex Chain | 5333609.0248425659,2184683.8496459229,360.76160916137832 | 0 | 0 | 0 | -0.56838596612215042,-3.2596290111541748e-09,-0.60166551019823922 | 0,0.19732568459585309,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.274Z | Complex Chain | 5333609.0305693373,2184683.8661425915,360.46503322541133 | 0 | 0 | 0 | -1.0722831450402737,0,0 | 3.1122308674635946e-07,0.37226350931450725,0.29686437971525947
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.285Z | Complex Chain | 5333609.1447722772,2184684.1950965272,360.76007120817735 | 0 | 0 | 0 | -0.56838596519082785,-3.2596290111541748e-09,-0.60166551019738657 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.296Z | Complex Chain | 5333609.1504990486,2184684.2115931958,360.46349527221128 | 0 | 0 | 0 | -1.0722831450402737,0,0 | 3.1215440932097493e-07,0.37226350931450725,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.305Z | Complex Chain | 5333609.2697278522,2184684.5550238565,360.75291058282494 | 0 | 0 | 0 | -0.56838596612215042,-3.7252902984619141e-09,-0.60166551019710235 | 0,0.19732568459585309,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.313Z | Complex Chain | 5333609.2754546246,2184684.571520525,360.45633464685704 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.0919909477233887e-07,0.37226350931450725,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.322Z | Complex Chain | 5333609.3946834281,2184684.9149511876,360.74574995616086 | 0 | 0 | 0 | -0.56838596891611814,-3.7252902984619141e-09,-0.60166551019715919 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.331Z | Complex Chain | 5333609.5196389994,2184685.2748785168,360.73858933066043 | 0 | 0 | 0 | -0.56838596519082785,-3.7252902984619141e-09,-0.60166551019704551 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.341Z | Complex Chain | 5333609.5253657717,2184685.2913751854,360.44201339469618 | 0 | 0 | 0 | -1.0722831441089511,0,0 | 3.1029176417174398e-07,0.37226350931450725,0.29686437971429314
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.350Z | Complex Chain | 5333609.6395687303,2184685.6203291928,360.73171671208991 | 0 | 0 | 0 | -0.568385967053473,-4.1909515857696533e-09,-0.6016655101966476 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.360Z | Complex Chain | 5333609.6452955008,2184685.6368258619,360.43514077612474 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1122308674635946e-07,0.37226350884884596,0.2968643797197501
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.371Z | Complex Chain | 5333609.7594984602,2184685.9657798689,360.72484409360385 | 0 | 0 | 0 | -0.568385967053473,-2.7939677238464355e-09,-0.60166551019613601 | 0,0.19732568506151438,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.383Z | Complex Chain | 5333609.7652252316,2184685.9822765375,360.42826815763777 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1029176417174398e-07,0.37226350931450725,0.29686437971702162
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.392Z | Complex Chain | 5333609.8794281892,2184686.311230544,360.71797147507147 | 0 | 0 | 0 | -0.568385967053473,-2.7939677238464355e-09,-0.60166551019681813 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.404Z | Complex Chain | 5333609.8851549607,2184686.327727213,360.42139553910357 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.0936044158325071e-07,0.37226350884884596,0.29686437971889745
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.412Z | Complex Chain | 5333609.9993579201,2184686.6566812219,360.71109885613578 | 0 | 0 | 0 | -0.568385967053473,-3.7252902984619141e-09,-0.60166551019499914 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.423Z | Complex Chain | 5333610.0050846906,2184686.67317789,360.41452292017152 | 0 | 0 | 0 | -1.0722831450402737,0,0 | 3.1106173992156982e-07,0.37226350931450725,0.29686437971616897
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.434Z | Complex Chain | 5333610.1243134933,2184687.0166085502,360.70393822995493 | 0 | 0 | 0 | -0.568385967053473,-3.2596290111541748e-09,-0.60166551019806869 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.445Z | Complex Chain | 5333610.1300402628,2184687.0331052183,360.40736229399067 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.119930624961853e-07,0.37226350931450725,0.29686437971707846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.456Z | Complex Chain | 5333610.2492690664,2184687.3765358804,360.69677760420467 | 0 | 0 | 0 | -0.56838596798479557,-3.2596290111541748e-09,-0.60166551019937609 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.465Z | Complex Chain | 5333610.3742246404,2184687.7364632124,360.68961697682658 | 0 | 0 | 0 | -0.56838596612215042,-4.1909515857696533e-09,-0.60166551019858028 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.473Z | Complex Chain | 5333610.3799514128,2184687.7529598805,360.39304104085869 | 0 | 0 | 0 | -1.0722831478342414,0,0 | 3.1029176417174398e-07,0.37226350931450725,0.29686437971889745
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.483Z | Complex Chain | 5333610.4941543704,2184688.0819138889,360.68274435937337 | 0 | 0 | 0 | -0.56838596798479557,-3.7252902984619141e-09,-0.60166551019670445 | 0,0.19732568459585309,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.492Z | Complex Chain | 5333610.4998811418,2184688.0984105566,360.38616842340821 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.0936044158325071e-07,0.37226351071149111,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.503Z | Complex Chain | 5333610.6140841004,2184688.4273645664,360.67587174064118 | 0 | 0 | 0 | -0.56838596425950527,-3.7252902984619141e-09,-0.60166551019789816 | 0,0.19732568459585309,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.511Z | Complex Chain | 5333610.6198108736,2184688.4438612349,360.37929580467238 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1013041734695435e-07,0.37226350978016853,0.29686437971793112
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.522Z | Complex Chain | 5333610.7340138322,2184688.7728152457,360.66899912252757 | 0 | 0 | 0 | -0.568385967053473,-3.7252902984619141e-09,-0.60166551019886449 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.533Z | Complex Chain | 5333610.7397406045,2184688.7893119133,360.37242318656058 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1106173992156982e-07,0.37226351024582982,0.29686437971611213
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.544Z | Complex Chain | 5333610.8539435631,2184689.1182659231,360.66212650402423 | 0 | 0 | 0 | -0.568385967053473,-3.2596290111541748e-09,-0.60166551019727288 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.553Z | Complex Chain | 5333610.8596703336,2184689.1347625912,360.36555056805906 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1029176417174398e-07,0.37226350931450725,0.29686437971889745
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.562Z | Complex Chain | 5333610.9788991362,2184689.4781932551,360.65496587619742 | 0 | 0 | 0 | -0.568385967053473,-3.2596290111541748e-09,-0.6016655101962497 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.571Z | Complex Chain | 5333610.9846259067,2184689.4946899242,360.35838994023135 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1029176417174398e-07,0.37226350931450725,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.583Z | Complex Chain | 5333611.1038547093,2184689.8381205839,360.64780525027913 | 0 | 0 | 0 | -0.56838596612215042,-3.7252902984619141e-09,-0.60166551019642023 | 0,0.19732568366453052,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.592Z | Complex Chain | 5333611.2288102834,2184690.1980479145,360.64064462541182 | 0 | 0 | 0 | -0.56838596519082785,-3.2596290111541748e-09,-0.60166551019732972 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.602Z | Complex Chain | 5333611.2345370566,2184690.2145445822,360.34406868944393 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1013041734695435e-07,0.37226351024582982,0.29686437971702162
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.610Z | Line | 5333606.6571687981,2184678.0123124216,358.72820008465663 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279806613922,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.620Z | Line | 5333606.7770985365,2184678.3577630967,358.72819993679474 | 0 | 0 | 0 | -0.86382386740297079,0,0 | 0,0.2998927989974618,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.630Z | Line | 5333606.8970282748,2184678.7032137732,358.72819978834235 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.2998927989974618,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.641Z | Line | 5333607.0169580132,2184679.0486644497,358.72819964046505 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.29989279853180051,1.0359871680520882e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.664Z | Line | 5333607.1368877506,2184679.3941151262,358.72819949237964 | 0 | 0 | 0 | -0.86382386274635792,0,0 | 0,0.2998927989974618,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.675Z | Line | 5333607.5117544979,2184680.4738971172,358.72819902936192 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.29989279946312308,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.686Z | Line | 5333607.6316842372,2184680.8193477951,358.72819888162809 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.29989279946312308,1.0359871680520882e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.696Z | Line | 5333607.7516139746,2184681.1647984707,358.72819873387067 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.2998927989974618,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.708Z | Line | 5333607.8715437148,2184681.5102491486,358.72819858623768 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279853180051,1.0359871680520882e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.726Z | Line | 5333607.9914734522,2184681.8556998256,358.72819843797606 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279666915536,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.736Z | Line | 5333608.3663401986,2184682.9354818137,358.7281979753871 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.29989279946312308,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.745Z | Line | 5333608.4862699369,2184683.2809324912,358.72819782708007 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.29989279946312308,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.756Z | Line | 5333608.6061996762,2184683.6263831686,358.72819767890843 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.29989279853180051,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.767Z | Line | 5333608.7261294117,2184683.9718338442,358.72819753138714 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.2998927989974618,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.776Z | Line | 5333608.8460591519,2184684.3172845221,358.72819738300927 | 0 | 0 | 0 | -0.86382386274635792,0,0 | 0,0.29989279992878437,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.786Z | Line | 5333609.2209258992,2184685.3970665131,358.72819692030129 | 0 | 0 | 0 | -0.86382386274635792,0,0 | 0,0.29989279853180051,1.0359835300732811e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.794Z | Line | 5333609.3408556366,2184685.7425171891,358.72819677218689 | 0 | 0 | 0 | -0.86382386181503534,0,0 | 0,0.29989279760047793,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.802Z | Line | 5333609.4607853759,2184686.0879678661,358.7281966249281 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.29989279853180051,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.810Z | Line | 5333609.5807151133,2184686.4334185394,358.72819647651482 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.2998927989974618,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.820Z | Line | 5333609.7006448526,2184686.7788692173,358.7281963286602 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.29989279806613922,1.03598807754679e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.828Z | Line | 5333610.075511598,2184687.8586512078,358.72819586560252 | 0 | 0 | 0 | -0.86382386274635792,0,0 | 0,0.29989279853180051,1.0359826205785794e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.838Z | Line | 5333610.1954413373,2184688.2041018866,358.7281957179386 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.29989279946312308,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.846Z | Line | 5333610.3153710766,2184688.5495525631,358.72819556951805 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.29989279946312308,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.857Z | Line | 5333610.4353008168,2184688.8950032424,358.72819542161983 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.2998927989974618,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.867Z | Line | 5333610.5552305542,2184689.2404539241,358.72819527407671 | 0 | 0 | 0 | -0.86382386274635792,0,0 | 0,0.2998927989974618,1.0359853490626847e-06
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.877Z | Line String | 5333606.9805806288,2184683.9614262641,359.793412383516 | 0 | 0 | 0 | 0,0,-2.2255042040342232e-06 | 1.8349570399150252,1.6619801679626107,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.887Z | Line String | 5333606.9805796584,2184683.9614262502,359.79499963107185 | 0 | 0 | 0 | 0,0,-2.2255043177210609e-06 | 1.8349570389837027,1.6619801679626107,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.900Z | Smart Solid | 5333608.7315851478,2184683.9875450884,359.79499752423851 | 90.8546 | 4.09222e-07 | 0.0000689314 | -6.7056134114548707,-5.644149372383351e-11,-1.0667999999999997 | -2.280369921450092e-10,3.4137278392783501,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.912Z | Smart Solid | 5333607.7586092306,2184683.9730317122,359.79499869493606 | 90.8546 | 4.09222e-07 | 0.0000689314 | -2.2802863084508484e-10,-3.4137278394880535,-1.0667999999999997 | 6.7056134109988061,-1.5325847790284217e-10,1.4568634832559876e-21
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.924Z | Smart Solid | 5333605.4254479446,2184676.749216096,359.79500157988383 | 90.8546 | 4.09222e-07 | 0.0000689314 | -2.2800802574034489e-10,-0.97308415489431066,-1.0667999999999997 | 0.48259999977200463,2.5766730237094734e-10,4.1291556465965595e-22
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.936Z | Smart Solid | 5333610.0989684109,2184690.7143010078,359.79499580654004 | 90.8546 | 4.09222e-07 | 0.0000689314 | -2.2804926057815478e-10,-0.97308415488307054,-1.0667999999999997 | 0.48259999977195717,2.6891007237801745e-10,4.1291556465965759e-22
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.947Z | Smart Solid | 5333606.3912272053,2184677.2462758026,360.8228395287108 | 90.8546 | 4.09222e-07 | 0.0000689314 | 1.2817906908331499e-10,-2.8460954154167513,-0.87934823469646928 | 6.7056134113550119,7.9386159701055198e-11,1.2164618007954076e-21
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.960Z | Smart Solid | 5333608.7315863837,2184683.9875450991,360.82283664031672 | 90.8546 | 4.09222e-07 | 0.0000689314 | 1.2815843936187351e-10,-2.8460954159368201,-0.89611226822453627 | 6.7056134113549914,-4.4068179872380417e-10,-1.1102108600071484e-16
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.971Z | Line | 5333606.3101431997,2184677.2450663289,358.72820051019204 | 0 | 0 | 0 | 0,0,-5.7767219914239831e-06 | 4.6807183604687452,13.482538592070341,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.980Z | Line | 5333606.5373662263,2184680.1552016772,360.64206521155489 | 0 | 0 | 0 | -0.76639424171298742,-2.2075542919337749,0 | 0,0,9.4585891474707751e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:24.991Z | Line | 5333606.4332357869,2184679.8552622283,359.98801403196728 | 0 | 0 | 0 | -0.55813493952155113,-1.607675408013165,0 | 0,0,6.8883377934980672e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.003Z | Line | 5333606.5373658342,2184680.1552016744,360.31503955750389 | 0 | 0 | 0 | -0.76639424264431,-2.2075542919337749,0 | 0,0,9.4585982424177928e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.012Z | Line | 5333607.3919519791,2184682.6167863766,360.68711418097666 | 0 | 0 | 0 | -0.76639423985034227,-2.2075542910024524,0 | 0,0,9.4585709575767396e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.022Z | Line | 5333607.3919515852,2184682.6167863738,360.36008852692657 | 0 | 0 | 0 | -0.76639423985034227,-2.2075542910024524,0 | 0,0,9.4585709575767396e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.030Z | Line | 5333607.2878215425,2184682.3168469276,360.03306300138723 | 0 | 0 | 0 | -0.55813494045287371,-1.6076754075475037,0 | 0,0,6.8883196036040317e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.041Z | Line | 5333608.2465377012,2184685.0783710931,360.72272685374838 | 0 | 0 | 0 | -0.76639423985034227,-2.2075542914681137,0 | 0,0,9.4585624310639105e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.051Z | Line | 5333608.2465373082,2184685.0783710903,360.39570119969738 | 0 | 0 | 0 | -0.76639424078166485,-2.2075542919337749,0 | 0,0,9.4585624310639105e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.060Z | Line | 5333608.1424072636,2184684.7784316451,360.06867567415895 | 0 | 0 | 0 | -0.55813493765890598,-1.607675408013165,0 | 0,0,6.8883110770912026e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.070Z | Line | 5333609.1011234233,2184687.5399557217,360.67792294759096 | 0 | 0 | 0 | -0.76639423985034227,-2.2075542919337749,0 | 0,0,9.4585806209579459e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.080Z | Line | 5333609.1011230294,2184687.5399557184,360.35089729353996 | 0 | 0 | 0 | -0.76639424078166485,-2.2075542919337749,0 | 0,0,9.4585988108519814e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.090Z | Line | 5333608.9969929866,2184687.2400162723,360.02387176800153 | 0 | 0 | 0 | -0.55813493952155113,-1.607675408013165,0 | 0,0,6.8883196036040317e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.101Z | Line | 5333609.955709137,2184690.0015403484,360.62502929691721 | 0 | 0 | 0 | -0.76639424078166485,-2.2075542928650975,0 | 0,0,9.4585891474707751e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.111Z | Line | 5333609.955708744,2184690.0015403451,360.29800364286621 | 0 | 0 | 0 | -0.76639424171298742,-2.2075542928650975,0 | 0,0,9.4585891474707751e-07
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.121Z | Line | 5333609.8515786994,2184689.701600899,359.97097811732687 | 0 | 0 | 0 | -0.55813493859022856,-1.6076754089444876,0 | 0,0,6.8883468884450849e-07
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.130Z | Complex Chain | 5333605.9851427115,2184678.5172345182,360.14942637003111 | 0 | 0 | 0 | -0.48280235100537539,-1.3928455431014299,-0.29525956475856674 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.139Z | Complex Chain | 5333606.8397284662,2184680.9788192166,360.19446546335263 | 0 | 0 | 0 | -0.48280235193669796,-1.3928455440327525,-0.29525956475755594 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.150Z | Complex Chain | 5333607.6943142209,2184683.4404039145,360.23950403616072 | 0 | 0 | 0 | -0.48280235193669796,-1.3928455431014299,-0.29525956475704435 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.159Z | Complex Chain | 5333608.5488999197,2184685.9019886116,360.23559684451999 | 0 | 0 | 0 | -0.48280235193669796,-1.3928455426357687,-0.29525956475909071 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.171Z | Complex Chain | 5333609.4034855543,2184688.3635733081,360.18274439261302 | 0 | 0 | 0 | -0.48280235007405281,-1.3928455421701074,-0.29525956475680459 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.180Z | Complex Chain | 5333610.2580711916,2184690.8251580084,360.12989029108502 | 0 | 0 | 0 | -0.48280235100537539,-1.3928455426357687,-0.29525956475856674 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.191Z | Line | 5333605.8726195898,2184678.3082098635,358.8234512156929 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.2817403078079224e-08,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.204Z | Line | 5333605.9925493272,2184678.6536605386,358.82345106740496 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.2817403078079224e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.217Z | Line | 5333606.1124790665,2184678.9991112174,358.82345091978829 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.3283064365386963e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.228Z | Line | 5333606.2324088039,2184679.3445618926,358.82345077145857 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.4680048227310181e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.239Z | Line | 5333606.3523385422,2184679.6900125695,358.823450622959 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.4214386940002441e-08,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.250Z | Line | 5333606.7272053417,2184680.7697945624,358.86790025023612 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672048734
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.261Z | Line | 5333606.847135081,2184681.1152452407,358.86790010150304 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.2817403078079224e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.273Z | Line | 5333606.9670648184,2184681.4606959154,358.86789995414256 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672058397
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.284Z | Line | 5333607.0869945595,2184681.8061465933,358.86789980651139 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.2817403078079224e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.294Z | Line | 5333607.206924296,2184682.1515972679,358.8678996581553 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672058397
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.304Z | Line | 5333607.5817910992,2184683.2313792584,358.91234928404805 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3748725652694702e-08,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.314Z | Line | 5333607.7017208366,2184683.5768299359,358.9123491357247 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.325Z | Line | 5333607.821650574,2184683.9222806129,358.91234898774019 | 0 | 0 | 0 | 0,0,0 | 2.5685876607894897e-06,2.2351741790771484e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.337Z | Line | 5333607.9415803123,2184684.267731288,358.91234883968571 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.2817403078079224e-08,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.346Z | Line | 5333608.0615100507,2184684.6131819678,358.91234869178925 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.356Z | Line | 5333608.4363767952,2184685.6929639569,358.90917322319939 | 0 | 0 | 0 | 0,0,0 | 2.5685876607894897e-06,2.3748725652694702e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.368Z | Line | 5333608.5563065335,2184686.0384146324,358.90917307526752 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.378Z | Line | 5333608.6762362737,2184686.3838653094,358.90917292769996 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3748725652694702e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.389Z | Line | 5333608.7961660102,2184686.7293159831,358.90917277940747 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3748725652694702e-08,2.1336042672057829
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.401Z | Line | 5333609.2909624306,2184688.1545486501,358.85678456360819 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.411Z | Line | 5333609.4108921718,2184688.499999329,358.85678441612959 | 0 | 0 | 0 | 0,0,0 | 2.5648623704910278e-06,2.4214386940002441e-08,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.422Z | Line | 5333609.5308219101,2184688.8454500064,358.85678426775991 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.432Z | Line | 5333609.6507516494,2184689.1909006857,358.85678411996344 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.4214386940002441e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.443Z | Line | 5333609.7706813887,2184689.5363513669,358.85678397149559 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.457Z | Line | 5333610.1623183768,2184690.6644392549,358.80439588294081 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.465Z | Line | 5333606.5924725188,2184678.0582992993,358.82345035214013 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.474Z | Line | 5333606.7124022571,2184678.4037499749,358.8234502041247 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.2351741790771484e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.482Z | Line | 5333606.8323319983,2184678.7492006528,358.82345005603389 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.491Z | Line | 5333606.9522617348,2184679.0946513275,358.8234499081874 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.2351741790771484e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.499Z | Line | 5333607.0721914722,2184679.440102003,358.82344975951617 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.509Z | Line | 5333607.4470582781,2184680.5198839954,358.86789938719568 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.2351741790771484e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.521Z | Line | 5333607.5669880174,2184680.8653346729,358.86789923910123 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.1886080503463745e-08,2.1336042672057829
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.529Z | Line | 5333607.6869177558,2184681.2107853484,358.86789909118841 | 0 | 0 | 0 | 0,0,0 | 2.5685876607894897e-06,2.1886080503463745e-08,2.1336042672049302
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.540Z | Line | 5333607.806847496,2184681.5562360263,358.86789894402506 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.1886080503463745e-08,2.1336042672058397
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.549Z | Line | 5333607.9267772296,2184681.9016867038,358.86789879491232 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.1886080503463745e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.561Z | Line | 5333608.3016440319,2184682.9814686929,358.91234842091768 | 0 | 0 | 0 | 0,0,0 | 2.5685876607894897e-06,2.3283064365386963e-08,2.1336042672058397
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.572Z | Line | 5333608.4215737702,2184683.3269193699,358.91234827311757 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.3748725652694702e-08,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.581Z | Line | 5333608.5415035086,2184683.6723700464,358.91234812489682 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672058397
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.592Z | Line | 5333608.661433246,2184684.017820722,358.91234797678425 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672094209
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.603Z | Line | 5333608.7813629834,2184684.3632714013,358.91234782868617 | 0 | 0 | 0 | 0,0,0 | 2.5685876607894897e-06,2.3283064365386963e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.613Z | Line | 5333609.156229727,2184685.4430533908,358.90917235989463 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3748725652694702e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.621Z | Line | 5333609.2761594644,2184685.7885040664,358.90917221187738 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.3748725652694702e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.628Z | Line | 5333609.3960892027,2184686.1339547434,358.90917206386104 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.3283064365386963e-08,2.1336042672058397
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.639Z | Line | 5333609.5160189392,2184686.4794054176,358.90917191597458 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.3748725652694702e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.654Z | Line | 5333609.6359486785,2184686.8248560946,358.9091717679047 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3748725652694702e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.665Z | Line | 5333610.0108153652,2184687.9046380837,358.85678370060225 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.676Z | Line | 5333610.1307451027,2184688.2500887625,358.85678355259955 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672094777
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.684Z | Line | 5333610.250674841,2184688.5955394399,358.85678340459685 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.692Z | Line | 5333610.3706045821,2184688.9409901188,358.85678325659507 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672094209
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.703Z | Line | 5333610.4905343233,2184689.2864407999,358.85678310926818 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.713Z | Line | 5333610.8654010026,2184690.3662227876,358.80439504086388 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.2817403078079224e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.725Z | Line | 5333607.3867989182,2184680.1139697856,358.72819918336808 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279946312308,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.734Z | Line | 5333607.2618433349,2184679.7540424569,358.72819933826264 | 0 | 0 | 0 | -0.86382386088371277,0,0 | 0,0.2998927989974618,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.746Z | Line | 5333607.3221026994,2184680.1599566643,358.86789954120184 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.2351741790771484e-08,2.1336042672048734
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.762Z | Line | 5333608.1164290393,2184682.2156271534,358.72819828344666 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.29989279713481665,1.0359871680520882e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.773Z | Line | 5333608.2413846198,2184682.5755544836,358.72819812900536 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279713481665,1.0359835300732811e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.782Z | Line | 5333608.1766884569,2184682.6215413623,358.91234857453327 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672067492
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.793Z | Line | 5333608.9710147427,2184684.6772118504,358.7281972283082 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279853180051,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.803Z | Line | 5333609.0959703224,2184685.0371391806,358.72819707409036 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279946312308,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.811Z | Line | 5333609.0312741492,2184685.0831260602,358.90917251368643 | 0 | 0 | 0 | 0,0,0 | 2.5685876607894897e-06,2.3748725652694702e-08,2.1336042672057829
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.818Z | Line | 5333609.8172700675,2184687.1148013901,358.72819618349251 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279853180051,1.03598807754679e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.827Z | Line | 5333609.7609042656,2184687.1847834219,358.90869424753038 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.3748725652694702e-08,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.836Z | Line | 5333609.9505560249,2184687.4987238771,358.72819601950783 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279806613922,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.845Z | Line | 5333609.8858597884,2184687.5447107549,358.85678385451035 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.854Z | Line | 5333610.6801861478,2184689.6003812472,358.72819511907409 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.2998927989974618,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.864Z | Line | 5333610.8051417191,2184689.9603085807,358.72819496514785 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279853180051,1.0359853490626847e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.873Z | Line | 5333610.7404454239,2184690.0062954561,358.80439519398624 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672057829
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.882Z | Line | 5333606.8921419354,2184677.527429848,360.65154189220419 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.12495519313961267,0.0022810166261706399
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.892Z | Line | 5333606.8864148054,2184677.5109331785,360.65125473442475 | 0 | 0 | 0 | -0.35992619954049587,0,0 | 0,0.12495519313961267,0.0022810166279327859
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.905Z | Complex Chain | 5333606.8309259992,2184677.5301971384,360.65160636522558 | 0 | 0 | 0 | -0.56838596798479557,-3.2596290111541748e-09,-0.60166551019681813 | 0,0.19732568459585309,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.914Z | Line | 5333606.5322132166,2184677.6523850905,358.7282002384548 | 0 | 0 | 0 | -0.86382386460900307,0,0 | 0,0.29989279853180051,1.0359862585573865e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.927Z | Line | 5333606.4218952516,2184677.3346205722,358.72820037553879 | 0 | 0 | 0 | -0.97297591529786587,-0.014513376168906689,0 | 0,0,1.170697601082793e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.938Z | Line | 5333606.4675169438,2184677.6983719687,358.82345050661684 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2351741790771484e-08,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.947Z | Line | 5333606.3485707538,2184677.3557543443,358.82345065352678 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672094209
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.959Z | Line | 5333605.5005019158,2184676.8265442727,358.80440164083126 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.3748725652694702e-08,2.1336042672049302
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.967Z | Line | 5333605.4970923821,2184677.0551193026,358.80440164182596 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3748725652694702e-08,2.1336042672057829
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.975Z | Line | 5333605.5170606794,2184677.2840430462,358.8044016152341 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.3748725652694702e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.984Z | Line | 5333610.1725070504,2184690.8932171208,358.80439586848672 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.3748725652694702e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:25.993Z | Line | 5333610.1690975158,2184691.1217921511,358.8043958703816 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.3283064365386963e-08,2.1336042672058397
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.002Z | Line | 5333606.3141398067,2184676.8815482422,358.80440066138692 | 0 | 0 | 0 | 0,0,0 | 2.5648623704910278e-06,2.2817403078079224e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.011Z | Line | 5333606.3123403294,2184677.002185063,358.80440066224804 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.2817403078079224e-08,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.020Z | Line | 5333606.310540854,2184677.1228218847,358.80440066310922 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.2817403078079224e-08,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.030Z | Line | 5333610.987154712,2184691.0911273314,358.80439488654707 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.040Z | Line | 5333610.9889541883,2184690.9704905101,358.80439488568504 | 0 | 0 | 0 | 0,0,0 | 2.5657936930656433e-06,2.3283064365386963e-08,2.1336042672076019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.049Z | Line | 5333610.9907536646,2184690.8498536893,358.80439488482477 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3283064365386963e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.062Z | Line | 5333611.0258965809,2184690.5961801969,358.7281946923805 | 0 | 0 | 0 | -0.86382386367768049,0,0 | 0,0.29989279806613922,1.0359844395679829e-06
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.072Z | Line | 5333610.9612002857,2184690.6421670737,358.80439492306198 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.2817403078079224e-08,2.1336042672067492
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.079Z | Complex Chain | 5333602.6885587666,2184677.2567047901,360.93376183515619 | 0 | 0 | 0 | 0,0,-0.99382721777402594 | 3.6445018092407833,0.054363141302019358,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.088Z | Complex Chain | 5333602.8084394773,2184677.6020173277,360.93960183228137 | 0 | 0 | 0 | 0,0,-0.99382721777675442 | 3.6445018111034284,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.097Z | Complex Chain | 5333602.9333950672,2184677.9619446583,360.94618879376048 | 0 | 0 | 0 | 0,0,-0.9938272177739691 | 3.6445018101721058,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.106Z | Complex Chain | 5333603.053324813,2184678.3073953344,360.95251080696016 | 0 | 0 | 0 | 0,0,-0.9938272177730596 | 3.6445018099620938,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.114Z | Complex Chain | 5333603.1732545588,2184678.6528460109,360.95883282802822 | 0 | 0 | 0 | 0,0,-0.99382721777493543 | 3.6445018108934164,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.125Z | Complex Chain | 5333603.2931843065,2184678.998296686,360.96515484903722 | 0 | 0 | 0 | 0,0,-0.99382721777584493 | 3.6445018101721058,0.054363142579836959,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.134Z | Complex Chain | 5333603.4131140504,2184679.3437473634,360.97147686974733 | 0 | 0 | 0 | 0,0,-0.99382721777311644 | 3.6445018101721058,0.054363143045498247,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.142Z | Complex Chain | 5333603.538069644,2184679.7036746922,360.97804237796726 | 0 | 0 | 0 | 0,0,-0.9938272177739691 | 3.6445018090307713,0.054363143045498247,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.152Z | Complex Chain | 5333603.6630252348,2184680.0636020233,360.98465078027544 | 0 | 0 | 0 | 0,0,-0.99382721777311644 | 3.6445018092407833,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.161Z | Complex Chain | 5333603.7879808219,2184680.4235293549,360.9912377354014 | 0 | 0 | 0 | 0,0,-0.99382721777675442 | 3.6445018111034284,0.054363141648514385,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.170Z | Complex Chain | 5333603.9079105686,2184680.7689800328,360.99755975653392 | 0 | 0 | 0 | 0,0,-0.99382721777311644 | 3.6445018101721058,0.054363141648514385,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.181Z | Complex Chain | 5333604.0278403154,2184681.1144307069,361.0038817772695 | 0 | 0 | 0 | 0,0,-0.99382721777311644 | 3.6445018101721058,0.054363142233341932,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.191Z | Complex Chain | 5333604.1477700612,2184681.4598813863,361.01020379794875 | 0 | 0 | 0 | 0,0,-0.99382721777493543 | 3.6445018111034284,0.054363141767680645,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.199Z | Complex Chain | 5333604.2676998051,2184681.8053320628,361.01652581923662 | 0 | 0 | 0 | 0,0,-0.99382721777493543 | 3.6445018101721058,0.054363142233341932,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.212Z | Complex Chain | 5333604.3926553968,2184682.1652593939,361.02309132822683 | 0 | 0 | 0 | 0,0,-0.99382721777402594 | 3.6445018101721058,0.054363141182853097,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.225Z | Complex Chain | 5333604.5176109923,2184682.5251867208,361.02969972892714 | 0 | 0 | 0 | 0,0,-0.99382721777578809 | 3.6445018101721058,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.239Z | Complex Chain | 5333604.6425665775,2184682.8851140523,361.03628668454729 | 0 | 0 | 0 | 0,0,-0.99382721777493543 | 3.6445018092407833,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.248Z | Complex Chain | 5333604.7624963224,2184683.2305647298,361.04230405142329 | 0 | 0 | 0 | 0,0,-0.99382721777487859 | 3.6445018090307713,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.256Z | Complex Chain | 5333604.8824260663,2184683.5760154072,361.0460588671001 | 0 | 0 | 0 | 0,0,-0.9938272177739691 | 3.6445018092407833,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.266Z | Complex Chain | 5333605.0023558056,2184683.9214660814,361.04721998819377 | 0 | 0 | 0 | 0,0,-0.99382721777493543 | 3.6445018101721058,0.054363142579836959,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.276Z | Complex Chain | 5333605.1222855421,2184684.2669167612,361.04559182645869 | 0 | 0 | 0 | 0,0,-0.99382721777584493 | 3.6445018099620938,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.287Z | Complex Chain | 5333605.2472411236,2184684.6268440899,361.04092859139695 | 0 | 0 | 0 | 0,0,-0.99382721777402594 | 3.6445018092407833,0.054363141648514385,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.295Z | Complex Chain | 5333605.3721966986,2184684.9867714206,361.0338223554761 | 0 | 0 | 0 | 0,0,-0.99382721777402594 | 3.6445018090307713,0.054363141182853097,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.306Z | Complex Chain | 5333605.4971522652,2184685.3466987503,361.02608836555237 | 0 | 0 | 0 | 0,0,-0.99382721777584493 | 3.6445018101721058,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.315Z | Complex Chain | 5333605.6170819961,2184685.6921494268,361.01866544458181 | 0 | 0 | 0 | 0,0,-0.9938272177730596 | 3.6445018083094607,0.054363142579836959,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.326Z | Complex Chain | 5333605.7370117251,2184686.0376001033,361.01124252396647 | 0 | 0 | 0 | 0,0,-0.99382721777669758 | 3.6445018101721058,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.337Z | Complex Chain | 5333605.8569414541,2184686.383050777,361.00381960322215 | 0 | 0 | 0 | 0,0,-0.99382721777584493 | 3.6445018092407833,0.054363142579836959,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.347Z | Complex Chain | 5333605.9768711813,2184686.7285014545,360.99639668292656 | 0 | 0 | 0 | 0,0,-0.99382721777766392 | 3.6445018111034284,0.054363141648514385,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.358Z | Complex Chain | 5333606.10182676,2184687.0884287823,360.98870091676361 | 0 | 0 | 0 | 0,0,-0.99382721777857341 | 3.644501811824739,0.054363141648514385,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.370Z | Complex Chain | 5333606.2267823359,2184687.4483561148,360.9809287028184 | 0 | 0 | 0 | 0,0,-0.99382721777311644 | 3.6445018101721058,0.054363141648514385,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.380Z | Complex Chain | 5333606.3517379034,2184687.808283445,360.97319471290285 | 0 | 0 | 0 | 0,0,-0.99382721777578809 | 3.6445018092407833,0.054363142233341932,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.392Z | Complex Chain | 5333606.4716676306,2184688.1537341233,360.96577179220031 | 0 | 0 | 0 | 0,0,-0.99382721777584493 | 3.6445018099620938,0.054363142579836959,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.404Z | Complex Chain | 5333606.5915973606,2184688.4991848017,360.95834887129973 | 0 | 0 | 0 | 0,0,-0.99382721777584493 | 3.6445018092407833,0.054363141182853097,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.416Z | Complex Chain | 5333606.7115270933,2184688.8446354801,360.95092595071708 | 0 | 0 | 0 | 0,0,-0.99382721777311644 | 3.6445018083094607,0.054363141648514385,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.430Z | Complex Chain | 5333606.8314568233,2184689.1900861608,360.94339159153651 | 0 | 0 | 0 | 0,0,-0.99382721777493543 | 3.6445018101721058,0.054363141302019358,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.442Z | Complex Chain | 5333606.9564124011,2184689.5500134854,360.93580726370078 | 0 | 0 | 0 | 0,0,-0.99382721777584493 | 3.6445018108934164,0.054363142579836959,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.450Z | Complex Chain | 5333607.0813679677,2184689.9099408169,360.92803504958482 | 0 | 0 | 0 | 0,0,-0.99382721777311644 | 3.6445018090307713,0.054363142233341932,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.458Z | Complex Chain | 5333607.2063235389,2184690.2698681471,360.92023416664637 | 0 | 0 | 0 | 0,0,-0.99382721777493543 | 3.6445018092407833,0.054363142114175672,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.468Z | Complex Chain | 5333611.1095814826,2184689.8546172539,360.35122931423399 | 0 | 0 | 0 | -1.1023750640451908,0,0 | 3.1029176417174398e-07,0.13068246562033892,0.30355166567744618
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.476Z | Complex Chain | 5333610.2549958387,2184687.3930325522,360.40020166942855 | 0 | 0 | 0 | -1.1023750631138682,0,0 | 3.1215440932097493e-07,0.13068246468901634,0.30355166567835568
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.492Z | Complex Chain | 5333609.4004101986,2184684.9314478575,360.4491740213021 | 0 | 0 | 0 | -1.1023750640451908,0,0 | 3.1106173992156982e-07,0.13068246515467763,0.30355166567744618
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.502Z | Complex Chain | 5333608.5458245147,2184682.4698632322,360.44072817690011 | 0 | 0 | 0 | -1.1023750631138682,0,0 | 3.1122308674635946e-07,0.13068246562033892,0.30355166567744618
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.513Z | Complex Chain | 5333607.6912387488,2184680.0082784574,360.39787937114357 | 0 | 0 | 0 | -1.1023750631138682,0,0 | 3.1122308674635946e-07,0.13068246515467763,0.3035516656747177
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.524Z | Complex Chain | 5333606.836652793,2184677.5466938303,360.35503045671061 | 0 | 0 | 0 | -1.1023750631138682,0,0 | 3.1122308674635946e-07,0.13068246468901634,0.30355166567653669
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.536Z | Line | 5333608.9160957485,2184687.0747666601,358.90917263129211 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.4214386940002441e-08,2.1336042672049302
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.546Z | Line | 5333610.6154898414,2184689.6463681287,358.80439534917144 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.2817403078079224e-08,2.1336042672076587
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.556Z | Line | 5333610.9300973034,2184690.3202359094,358.72819481100817 | 0 | 0 | 0 | -0.86382386554032564,0,0 | 0,0.2998927989974618,1.0359862585573865e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.571Z | Complex Chain | 5333607.3021228127,2184690.5458124336,360.91474435357514 | 0 | 0 | 0 | 0,0,-0.9938272177739691 | 3.6445018092407833,0.054363141767680645,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.582Z | Complex Chain | 5333611.3303363286,2184690.4904888691,360.33857887637271 | 0 | 0 | 0 | -1.0722831459715962,0,0 | 3.1029176417174398e-07,0.37226350884884596,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.594Z | Complex Chain | 5333611.3246095572,2184690.4739922006,360.63515481233969 | 0 | 0 | 0 | -0.568385967053473,-4.1909515857696533e-09,-0.60166551019607917 | 0,0.19732568366453052,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.611Z | Line | 5333608.9063185696,2184684.7231987328,358.91234767423759 | 0 | 0 | 0 | 0,0,0 | 2.5648623704910278e-06,2.2817403078079224e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.624Z | Line | 5333608.0517328158,2184682.2616140335,358.86789864030845 | 0 | 0 | 0 | 0,0,0 | 2.5676563382148743e-06,2.1886080503463745e-08,2.1336042672066924
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.632Z | Line | 5333607.1971470611,2184679.8000293355,358.82344960641746 | 0 | 0 | 0 | 0,0,0 | 2.5667250156402588e-06,2.3748725652694702e-08,2.1336042672057829
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.644Z | Complex Chain | 5333606.3103010301,2184676.8211591365,360.55065209147904 | 0 | 0 | 0 | -0.78569920267909765,-0.011625567451119423,0 | 0,0.82010827353224158,9.4078473011904862e-07
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.655Z | Complex Chain | 5333606.310300665,2184676.8211591323,360.24585148187782 | 0 | 0 | 0 | -0.7856992045417428,-0.011625567451119423,0 | 0,0.82010827399790287,9.4078654910845216e-07
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.666Z | Complex Chain | 5333610.9783767154,2184691.1513282135,360.55064838875433 | 0 | 0 | 0 | -0.91467183828353882,-0.84335940750315785,0 | 0,0,1.1095075365119555e-06
