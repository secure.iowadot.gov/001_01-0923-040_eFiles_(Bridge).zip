Properties of the parts of a building model (IFC4X3_ADD2), part 9 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.452Z | Extended Element | 5333552.4250418944,2184677.1563215572,360.78325496323691 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.461Z | Extended Element | 5333552.7298056493,2184677.1608675644,360.78459607293769 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.469Z | Extended Element | 5333553.034569406,2184677.1654135729,360.78593718263778 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.477Z | Extended Element | 5333553.3393331617,2184677.169959581,360.78727829233685 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.489Z | Extended Element | 5333553.6440969175,2184677.1745055877,360.78861940203791 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.498Z | Extended Element | 5333553.9488606732,2184677.1790515962,360.78996051173823 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.508Z | Extended Element | 5333554.253624429,2184677.1835976033,360.79130162144099 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.519Z | Extended Element | 5333554.5583881838,2184677.1881436124,360.79264273113984 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.534Z | Extended Element | 5333554.8631520458,2184677.1926896209,360.79395991471694 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.544Z | Extended Element | 5333555.1679159068,2184677.1972356304,360.79527671628108 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.554Z | Extended Element | 5333555.4726797706,2184677.2017816403,360.79659351784989 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.572Z | Extended Element | 5333555.7774436986,2184677.2063276507,360.79789432320803 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.581Z | Extended Element | 5333556.0822077999,2184677.210873663,360.79915400499374 | -179.145 | 3.24244e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.592Z | Extended Element | 5333556.3869719049,2184677.2154196757,360.80041368677934 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.603Z | Extended Element | 5333556.6917360071,2184677.219965688,360.80167336856817 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.613Z | Extended Element | 5333556.9965001121,2184677.2245117016,360.80293305035349 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.630Z | Extended Element | 5333557.301264287,2184677.2290577153,360.80417435732448 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.642Z | Extended Element | 5333557.6060286555,2184677.2336037322,360.8053684157324 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.654Z | Extended Element | 5333557.9107930232,2184677.2381497491,360.80656247413998 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.664Z | Extended Element | 5333558.2155573899,2184677.242695766,360.8077565325471 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.676Z | Extended Element | 5333558.5203217575,2184677.2472417834,360.80895059095286 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.694Z | Extended Element | 5333558.8250861932,2184677.2517878008,360.81012627701949 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.705Z | Extended Element | 5333559.1298508123,2184677.2563338224,360.81125471188204 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.714Z | Extended Element | 5333559.4346154286,2184677.2608798421,360.81238314674778 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.726Z | Extended Element | 5333559.7393800458,2184677.2654258623,360.81351158160993 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.737Z | Extended Element | 5333560.0441446649,2184677.2699718834,360.81464001647265 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.754Z | Extended Element | 5333560.3489093482,2184677.2745179054,360.81575008120052 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.763Z | Extended Element | 5333560.6536742011,2184677.2790639298,360.81681289236116 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.776Z | Extended Element | 5333560.958439053,2184677.2836099532,360.81787570352117 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.786Z | Extended Element | 5333561.2632039068,2184677.2881559776,360.81893851468169 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.796Z | Extended Element | 5333561.5679687597,2184677.2927020006,360.82000132584523 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.814Z | Extended Element | 5333561.872733674,2184677.2972480259,360.82104576882233 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.825Z | Extended Element | 5333562.1774987504,2184677.3017940535,360.82204295613406 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.836Z | Extended Element | 5333562.4822638249,2184677.3063400812,360.82304014344737 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.844Z | Extended Element | 5333562.7870288985,2184677.3108861083,360.82403733076052 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.856Z | Extended Element | 5333563.0917939749,2184677.3154321364,360.82503451807332 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.873Z | Extended Element | 5333563.3965591071,2184677.3199781645,360.82601333891949 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.884Z | Extended Element | 5333563.7013243902,2184677.3245241954,360.82694490224327 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.894Z | Extended Element | 5333564.0060896734,2184677.3290702254,360.82787646556625 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.905Z | Extended Element | 5333564.3108549537,2184677.3336162562,360.82880802888837 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.914Z | Extended Element | 5333564.6156202378,2184677.3381622867,360.82973959221243 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.931Z | Extended Element | 5333564.920385574,2184677.3427083171,360.83065279056632 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.942Z | Extended Element | 5333565.2251510527,2184677.3472543512,360.83151872977368 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.952Z | Extended Element | 5333565.5299165258,2184677.3518003849,360.83238466897978 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.962Z | Extended Element | 5333565.8346820027,2184677.3563464181,360.83325060818686 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.974Z | Extended Element | 5333566.1394474776,2184677.3608924514,360.83411654739263 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.992Z | Extended Element | 5333566.4442130048,2184677.365438486,360.83496412291885 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.003Z | Extended Element | 5333566.7489786586,2184677.369984522,360.83576443788735 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.012Z | Extended Element | 5333567.0537443152,2184677.374530558,360.83656475285756 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.024Z | Extended Element | 5333567.358509969,2184677.379076594,360.83736506782446 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.035Z | Extended Element | 5333567.6632756256,2184677.38362263,360.83816538279336 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.054Z | Extended Element | 5333567.9680413259,2184677.3881686665,360.83894733518184 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.065Z | Extended Element | 5333568.2728071474,2184677.3927147053,360.8396820257999 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.076Z | Extended Element | 5333568.5775729679,2184677.3972607441,360.84041671642035 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.088Z | Extended Element | 5333568.8823387884,2184677.4018067829,360.84115140703858 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.098Z | Extended Element | 5333569.1871046089,2184677.4063528213,360.84188609765886 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.119Z | Extended Element | 5333569.4918704722,2184677.4108988601,360.84260242662054 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.129Z | Extended Element | 5333569.7966364436,2184677.4154449007,360.84327149278977 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.139Z | Extended Element | 5333570.101402415,2184677.419990941,360.84394055895825 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.151Z | Extended Element | 5333570.4061683873,2184677.4245369826,360.84460962512514 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.160Z | Extended Element | 5333570.7109343577,2184677.4290830228,360.84527869129124 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.177Z | Extended Element | 5333571.0157003682,2184677.4336290644,360.84592939656903 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.189Z | Extended Element | 5333571.3204664765,2184677.4381751069,360.84653283819279 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.198Z | Extended Element | 5333571.6252325857,2184677.4427211503,360.84713627981603 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.210Z | Extended Element | 5333571.929998694,2184677.4472671924,360.84773972144018 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.222Z | Extended Element | 5333572.2347648032,2184677.4518132359,360.84834316306171 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.239Z | Extended Element | 5333572.5395309459,2184677.4563592793,360.84892824441391 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.248Z | Extended Element | 5333572.8442971781,2184677.4609053233,360.84946606140869 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.256Z | Extended Element | 5333573.1490634093,2184677.4654513681,360.85000387840302 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.265Z | Extended Element | 5333573.4538296396,2184677.4699974135,360.85054169539967 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.274Z | Extended Element | 5333573.7585958736,2184677.4745434579,360.85107951239507 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.291Z | Extended Element | 5333574.0633621337,2184677.4790895032,360.85159896960948 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.302Z | Extended Element | 5333574.368128472,2184677.483635549,360.85207116189696 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.312Z | Extended Element | 5333574.6728948141,2184677.4881815962,360.85254335419035 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.322Z | Extended Element | 5333574.9776611533,2184677.4927276415,360.853015546481 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.332Z | Extended Element | 5333575.2824274944,2184677.4972736887,360.85348773877161 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.349Z | Extended Element | 5333575.5871938607,2184677.5018197349,360.85394157165831 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.359Z | Extended Element | 5333575.891960294,2184677.5063657826,360.85434813918192 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.369Z | Extended Element | 5333576.196726731,2184677.5109118298,360.85475470670428 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.380Z | Extended Element | 5333576.5014931671,2184677.5154578784,360.85516127422636 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.391Z | Extended Element | 5333576.8062595995,2184677.520003926,360.85556784174901 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.407Z | Extended Element | 5333577.111026057,2184677.5245499741,360.85595605014197 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.416Z | Extended Element | 5333577.4157925742,2184677.5290960222,360.85629699284033 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.424Z | Extended Element | 5333577.7205590867,2184677.5336420722,360.85663793553539 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.434Z | Extended Element | 5333578.0253256029,2184677.5381881199,360.8569788782342 | -179.145 | 3.24244e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.443Z | Extended Element | 5333578.3300921191,2184677.5427341699,360.85731982093074 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.460Z | Extended Element | 5333578.6348586539,2184677.5472802185,360.85764240468802 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.469Z | Extended Element | 5333578.9396252334,2184677.5518262684,360.85791772251292 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.480Z | Extended Element | 5333579.2443918167,2184677.5563723189,360.85819304033816 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.492Z | Extended Element | 5333579.5491583962,2184677.5609183679,360.85846835816221 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.500Z | Extended Element | 5333579.8539249785,2184677.5654644184,360.85874367598643 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.515Z | Extended Element | 5333580.158691573,2184677.5700104688,360.85900063499588 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.525Z | Extended Element | 5333580.4634582102,2184677.5745565193,360.85921032790827 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.535Z | Extended Element | 5333580.768224841,2184677.5791025697,360.85942002082118 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.545Z | Extended Element | 5333581.0729914755,2184677.5836486206,360.85962971373471 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.554Z | Extended Element | 5333581.3777581109,2184677.5881946716,360.8598394066471 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.571Z | Extended Element | 5333581.6825247547,2184677.5927407211,360.86003074081663 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.581Z | Extended Element | 5333581.9872914264,2184677.5972867724,360.86017480878854 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.591Z | Extended Element | 5333582.2920580963,2184677.6018328243,360.86031887676137 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.602Z | Extended Element | 5333582.5968247689,2184677.6063788757,360.86046294473562 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.612Z | Extended Element | 5333582.9015914416,2184677.6109249261,360.8606070127064 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.630Z | Extended Element | 5333583.2063581198,2184677.615470978,360.86073272196688 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.640Z | Extended Element | 5333583.5111248149,2184677.6200170289,360.86081116497905 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.649Z | Extended Element | 5333583.8158915127,2184677.6245630817,360.86088960799094 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.660Z | Extended Element | 5333584.1206582086,2184677.6291091326,360.86096805100294 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.672Z | Extended Element | 5333584.4254249036,2184677.6336551844,360.86104649401449 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.690Z | Extended Element | 5333584.7301916014,2184677.6382012363,360.86110937506299 | -179.145 | 3.24244e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.698Z | Extended Element | 5333585.0349583067,2184677.6427472876,360.86113219032842 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.710Z | Extended Element | 5333585.339725012,2184677.6472933395,360.86115500559089 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.721Z | Extended Element | 5333585.6444917172,2184677.6518393909,360.86117782085535 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.739Z | Extended Element | 5333585.9492584225,2184677.6563854427,360.86117428313952 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.756Z | Extended Element | 5333586.2540251277,2184677.660931495,360.86115230982148 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.765Z | Extended Element | 5333586.5587918283,2184677.6654775464,360.86109950288903 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.777Z | Extended Element | 5333586.863558528,2184677.6700235978,360.86104669595881 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.792Z | Extended Element | 5333587.1683252305,2184677.6745696496,360.86099388902659 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.804Z | Extended Element | 5333587.4730919329,2184677.6791157015,360.86094108209556 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.821Z | Extended Element | 5333587.7778586289,2184677.6836617528,360.86086991646249 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.830Z | Extended Element | 5333588.0826253109,2184677.6882078047,360.86075148456388 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.840Z | Extended Element | 5333588.3873919947,2184677.6927538561,360.86063305266885 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.849Z | Extended Element | 5333588.6921586767,2184677.697299907,360.86051462077211 | -179.145 | 3.24244e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.861Z | Extended Element | 5333588.9969253587,2184677.7018459584,360.86039618887446 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.879Z | Extended Element | 5333589.3016920341,2184677.7063920093,360.86025939830591 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.889Z | Extended Element | 5333589.6064586826,2184677.7109380602,360.86007534145904 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.899Z | Extended Element | 5333589.9112253338,2184677.7154841111,360.85989128461347 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.910Z | Extended Element | 5333590.2159919841,2184677.7200301629,360.85970722776625 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.923Z | Extended Element | 5333590.5207586363,2184677.7245762139,360.85952317091875 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.942Z | Extended Element | 5333590.8255252726,2184677.7291222648,360.85932075546793 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.953Z | Extended Element | 5333591.1302918764,2184677.7336683143,360.85907107369854 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.961Z | Extended Element | 5333591.4350584801,2184677.7382143647,360.85882139193131 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.970Z | Extended Element | 5333591.7398250839,2184677.7427604147,360.858571710158 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.978Z | Extended Element | 5333592.0445916848,2184677.7473064642,360.85832202838884 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:26.993Z | Extended Element | 5333592.3493582746,2184677.7518525152,360.85805398813523 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.003Z | Extended Element | 5333592.654124815,2184677.7563985651,360.85773868147487 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.011Z | Extended Element | 5333592.9588913582,2184677.7609446137,360.85742337481565 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.021Z | Extended Element | 5333593.2636579024,2184677.7654906632,360.85710806815729 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.031Z | Extended Element | 5333593.5684244456,2184677.7700367132,360.85679276149364 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.048Z | Extended Element | 5333593.8731909674,2184677.7745827613,360.85645909654261 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.059Z | Extended Element | 5333594.1779574361,2184677.7791288095,360.85607816503921 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.070Z | Extended Element | 5333594.482723902,2184677.783674858,360.85569723353575 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.079Z | Extended Element | 5333594.7874903688,2184677.7882209062,360.85531630202871 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.089Z | Extended Element | 5333595.0922568385,2184677.7927669543,360.85493537052554 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.104Z | Extended Element | 5333595.3970232811,2184677.7973130015,360.85453608099755 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.113Z | Extended Element | 5333595.7017896613,2184677.8018590491,360.85408952470033 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.122Z | Extended Element | 5333596.0065560387,2184677.8064050954,360.85364296840402 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.132Z | Extended Element | 5333596.311322419,2184677.810951143,360.85319641210805 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.142Z | Extended Element | 5333596.6160887973,2184677.8154971888,360.85274985581202 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.159Z | Extended Element | 5333596.9208551468,2184677.820043236,360.85228494185907 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.171Z | Extended Element | 5333597.2256214237,2184677.8245892809,360.85177276083465 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.179Z | Extended Element | 5333597.5303876959,2184677.8291353267,360.85126057980671 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.190Z | Extended Element | 5333597.8351539746,2184677.8336813711,360.85074839878155 | -179.145 | 1.83285e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.198Z | Extended Element | 5333598.1399202496,2184677.8382274169,360.85023621775576 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.216Z | Extended Element | 5333598.4446864929,2184677.8427734617,360.84970567955764 | -179.145 | 1.83285e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.227Z | Extended Element | 5333598.7494526515,2184677.8473195047,360.8491278738714 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.235Z | Extended Element | 5333599.0542188082,2184677.8518655496,360.84855006818742 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.243Z | Extended Element | 5333599.3589849668,2184677.8564115926,360.84797226250373 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.253Z | Extended Element | 5333599.6637511244,2184677.8609576365,360.84739445681515 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.269Z | Extended Element | 5333599.9685172476,2184677.8655036795,360.84679829457258 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.279Z | Extended Element | 5333600.2732832748,2184677.8700497206,360.84615486430823 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.290Z | Extended Element | 5333600.5780493021,2184677.8745957627,360.84551143404548 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.299Z | Extended Element | 5333600.8828153284,2184677.8791418043,360.84486800378147 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.311Z | Extended Element | 5333601.187581352,2184677.8836878454,360.84422457351775 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.327Z | Extended Element | 5333601.4923473401,2184677.888233888,360.84356278745099 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.337Z | Extended Element | 5333601.7971132221,2184677.8927799268,360.84285373269722 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.346Z | Extended Element | 5333602.1018791022,2184677.8973259665,360.84214467794556 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.358Z | Extended Element | 5333602.4066449841,2184677.9018720058,360.84143562319508 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.366Z | Extended Element | 5333602.7114108643,2184677.9064180451,360.84072656844194 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.385Z | Extended Element | 5333603.0161767006,2184677.9109640843,360.83999915880071 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.394Z | Extended Element | 5333603.3209424224,2184677.9155101203,360.83922447965995 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.406Z | Extended Element | 5333603.6257081442,2184677.9200561577,360.83844980051629 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.414Z | Extended Element | 5333603.9304738669,2184677.9246021952,360.83767512137274 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.426Z | Extended Element | 5333604.2352395859,2184677.9291482321,360.83690044222971 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.444Z | Extended Element | 5333604.5400052611,2184677.9336942681,360.83610740929112 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.455Z | Extended Element | 5333604.8447708078,2184677.9382403027,360.83526710586466 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.465Z | Extended Element | 5333605.1495363563,2184677.9427863373,360.83442680243843 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.476Z | Extended Element | 5333605.4543019058,2184677.947332371,360.83358649901322 | -179.145 | 1.83285e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.599Z | Extended Element | 5333550.6905247429,2184690.1207798794,361.86699897867953 | -89.1454 | 180 | -0.2521 | -0.0093039363192254851,-3.4347635870347887e-11,-0.0079374999989768203 | 0.0093043036975064396,10.904488888156054,0.027649986596041728
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.610Z | Extended Element | 5333560.6382150529,2184690.2691645739,361.90816455842565 | -89.1454 | -180 | -0.18745 | -0.0093038699880996674,-8.1541309412938795e-11,-0.0079375000028158015 | 0.0093039037823807666,10.099660152253898,0.029744165310693509
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.622Z | Extended Element | 5333570.5859512249,2184690.4175499547,361.93598631490488 | -89.1454 | -180 | -0.113434 | -0.0093038253532002711,-4.1040737745635178e-10,-0.0079375000020900227 | 0.0093038198270349731,10.818810003770457,0.03056526560380108
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.633Z | Extended Element | 5333580.533716307,2184690.5659357645,361.95010350443437 | -89.1454 | 180 | -0.0270816 | -0.0093039417150959421,4.8869752686923247e-10,-0.0079374999997726316 | 0.0093038720455859061,10.013946096879849,0.029854916691919288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.645Z | Extended Element | 5333590.4814913515,2184690.7143217251,361.94996814058038 | -89.1454 | 180 | 0.0469347 | -0.009303950987195846,8.5543040782056849e-10,-0.0079375000024633092 | 0.0093038118751423947,10.733097913579931,0.030694457656348598
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.657Z | Extended Element | 5333600.4292567763,2184690.8627075413,361.93610965510243 | -89.1454 | 180 | 0.133287 | -0.007937506303712696,-5.1331902948604173e-10,-0.0079375000010472509 | 0.0079375001358692812,10.918933532082919,0.014139106896929288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.707Z | Extended Element | 5333550.6897553755,2184690.1723580337,361.6976720800098 | -89.1454 | 180 | -0.2521 | -0.0093039363192254851,-3.4347635870347887e-11,-0.0079374999989768203 | 0.0093043036975064396,10.904488888156054,0.027649986596041728
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.716Z | Extended Element | 5333560.6374456892,2184690.3207427291,361.73883765976348 | -89.1454 | -180 | -0.18745 | -0.0093038699880996674,-8.1541309412938795e-11,-0.0079375000028158015 | 0.0093039037823807666,10.099660152253898,0.029744165310693509
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.727Z | Extended Element | 5333570.5851818575,2184690.469128109,361.76665941623565 | -89.1454 | -180 | -0.113434 | -0.0093038253532002711,-4.1040737745635178e-10,-0.0079375000020900227 | 0.0093038198270349731,10.818810003770457,0.03056526560380108
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.737Z | Extended Element | 5333580.5329469396,2184690.6175139206,361.78077660576793 | -89.1454 | 180 | -0.0270816 | -0.0093039417150959421,4.8869752686923247e-10,-0.0079374999997726316 | 0.0093038720455859061,10.013946096879849,0.029854916691919288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.745Z | Extended Element | 5333590.4807219859,2184690.7658998808,361.78064124191508 | -89.1454 | 180 | 0.0469347 | -0.009303950987195846,8.5543040782056849e-10,-0.0079375000024633092 | 0.0093038118751423947,10.733097913579931,0.030694457656348598
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.753Z | Extended Element | 5333600.4284874089,2184690.9142856966,361.7667827564444 | -89.1454 | 180 | 0.133287 | -0.007937506303712696,-5.1331902948604173e-10,-0.0079375000010472509 | 0.0079375001358692812,10.918933532082919,0.014139106896929288
