Properties of the parts of a building model (IFC4X3_ADD2), part 10 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.804Z | Extended Element | 5333550.6916677579,2184690.0441523669,361.69767207917738 | -89.1454 | 179.999 | -0.2521 | -0.0093039363192254851,-3.4347635870347887e-11,-0.0079374999989768203 | 0.0093043036975064396,10.904488888156054,0.027649986596041728
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.813Z | Extended Element | 5333560.6393580697,2184690.1925370614,361.73883765891827 | -89.1454 | -180 | -0.18745 | -0.0093038699880996674,-8.1541309412938795e-11,-0.0079375000028158015 | 0.0093039037823807666,10.099660152253898,0.029744165310693509
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.825Z | Extended Element | 5333570.5870942399,2184690.3409224413,361.76665941539233 | -89.1454 | -180 | -0.113434 | -0.0093038253532002711,-4.1040737745635178e-10,-0.0079375000020900227 | 0.0093038198270349731,10.818810003770457,0.03056526560380108
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.833Z | Extended Element | 5333580.5348593211,2184690.4893082525,361.78077660491465 | -89.1454 | 180 | -0.0270816 | -0.0093039417150959421,4.8869752686923247e-10,-0.0079374999997726316 | 0.0093038720455859061,10.013946096879849,0.029854916691919288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.843Z | Extended Element | 5333590.4826343674,2184690.6376942126,361.78064124105663 | -89.1454 | 180 | 0.0469347 | -0.009303950987195846,8.5543040782056849e-10,-0.0079375000024633092 | 0.0093038118751423947,10.733097913579931,0.030694457656348598
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.853Z | Extended Element | 5333600.4303997923,2184690.7860800293,361.76678275557799 | -89.1454 | 180 | 0.133287 | -0.007937506303712696,-5.1331902948604173e-10,-0.0079375000010472509 | 0.0079375001358692812,10.918933532082919,0.014139106896929288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.908Z | Extended Element | 5333550.6897553792,2184690.172358036,361.52833501954319 | -89.1454 | 179.999 | -0.2521 | -0.0093039363192254851,-3.4347635870347887e-11,-0.0079374999989768203 | 0.0093043036975064396,10.904488888156054,0.027649986596041728
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.916Z | Extended Element | 5333560.637445692,2184690.3207427305,361.56950059929642 | -89.1454 | -180 | -0.18745 | -0.0093038699880996674,-8.1541309412938795e-11,-0.0079375000028158015 | 0.0093039037823807666,10.099660152253898,0.029744165310693509
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.928Z | Extended Element | 5333570.5851818603,2184690.4691281104,361.59732235577195 | -89.1454 | -180 | -0.113434 | -0.0093038253532002711,-4.1040737745635178e-10,-0.0079375000020900227 | 0.0093038198270349731,10.818810003770457,0.03056526560380108
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.940Z | Extended Element | 5333580.5329469442,2184690.6175139216,361.61143954529871 | -89.1454 | -180 | -0.0270816 | -0.0093039417150959421,4.8869752686923247e-10,-0.0079374999997726316 | 0.0093038720455859061,10.013946096879849,0.029854916691919288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.949Z | Extended Element | 5333590.4807219896,2184690.7658998822,361.61130418144023 | -89.1454 | 180 | 0.0469347 | -0.009303950987195846,8.5543040782056849e-10,-0.0079375000024633092 | 0.0093038118751423947,10.733097913579931,0.030694457656348598
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:27.959Z | Extended Element | 5333600.4284874108,2184690.9142856975,361.5974456959633 | -89.1454 | 180 | 0.133287 | -0.007937506303712696,-5.1331902948604173e-10,-0.0079375000010472509 | 0.0079375001358692812,10.918933532082919,0.014139106896929288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.010Z | Extended Element | 5333550.6897553802,2184690.1723580365,361.07959740247924 | -89.1454 | 179.999 | -0.2521 | -0.0093039363192254851,-3.4347635870347887e-11,-0.0079374999989768203 | 0.0093043036975064396,10.904488888156054,0.027649986596041728
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.020Z | Extended Element | 5333560.637445692,2184690.320742731,361.12076298221859 | -89.1454 | -180 | -0.18745 | -0.0093038699880996674,-8.1541309412938795e-11,-0.0079375000028158015 | 0.0093039037823807666,10.099660152253898,0.029744165310693509
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.030Z | Extended Element | 5333570.5851818612,2184690.4691281109,361.14858473868941 | -89.1454 | -180 | -0.113434 | -0.0093038253532002711,-4.1040737745635178e-10,-0.0079375000020900227 | 0.0093038198270349731,10.818810003770457,0.03056526560380108
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.040Z | Extended Element | 5333580.5329469452,2184690.617513923,361.16270192821719 | -89.1454 | 180 | -0.0270816 | -0.0093039417150959421,4.8869752686923247e-10,-0.0079374999997726316 | 0.0093038720455859061,10.013946096879849,0.029854916691919288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.050Z | Extended Element | 5333590.4807219896,2184690.7658998827,361.16256656435849 | -89.1454 | 180 | 0.0469347 | -0.009303950987195846,8.5543040782056849e-10,-0.0079375000024633092 | 0.0093038118751423947,10.733097913579931,0.030694457656348598
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.058Z | Extended Element | 5333600.4284874126,2184690.9142856989,361.14870807887712 | -89.1454 | 180 | 0.133287 | -0.007937506303712696,-5.1331902948604173e-10,-0.0079375000010472509 | 0.0079375001358692812,10.918933532082919,0.014139106896929288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.238Z | Extended Element | 5333546.0185351297,2184676.0530819166,361.84552131295624 | -89.1454 | 179.999 | -0.2521 | -0.0093047471586866701,7.4875160232198621e-11,-0.0091645189644531874 | 0.0093044071883853427,10.922220028514715,0.025364652598086311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.250Z | Extended Element | 5333555.9662152827,2184676.2014664602,361.88913670353861 | -89.1454 | 180 | -0.236793 | -0.0093038806869239505,2.3281075592732768e-10,-0.0079375000022168934 | 0.0093038072373501889,10.408972711623887,0.0311829069498312
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.263Z | Extended Element | 5333565.9139290033,2184676.3498515049,361.92405637816745 | -89.1454 | 180 | -0.150442 | -0.0093051081625048649,2.8120093266334825e-10,-0.0079375000014654078 | 0.0093051624679593124,10.922208874914077,0.030573492443412148
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.276Z | Extended Element | 5333575.8616823321,2184676.4982371419,361.94481194436094 | -89.1454 | -180 | -0.0764257 | -0.0093038118739026694,2.1462004394512068e-10,-0.0079375000000568453 | 0.0093038650996267076,10.323271596130006,0.031312112833961292
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.289Z | Extended Element | 5333585.80945489,2184676.6466230634,361.95175618851363 | -89.1454 | -180 | 0.00992654 | -0.009305097826247298,3.2519395050301764e-10,-0.0079375000002328312 | 0.0093052049219524476,10.922208803466793,0.030684244234209856
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.299Z | Extended Element | 5333595.7572272504,2184676.7950089835,361.9445545584893 | -89.1454 | 180 | 0.0839427 | -0.0079375044749041574,6.6075724654429113e-10,-0.0079375000019011304 | 0.0079374998188037563,10.918954504581158,0.015855031694472128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.353Z | Extended Element | 5333546.0173921147,2184676.1297094282,361.67619441481509 | -89.1454 | 180 | -0.2521 | -0.0093047471586866701,7.4875160232198621e-11,-0.0091645189644531874 | 0.0093044071883853427,10.922220028514715,0.025364652598086311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.363Z | Extended Element | 5333555.9650722705,2184676.2780939736,361.71980980540758 | -89.1454 | 180 | -0.236793 | -0.0093038806869239505,2.3281075592732768e-10,-0.0079375000022168934 | 0.0093038072373501889,10.408972711623887,0.0311829069498312
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.373Z | Extended Element | 5333565.912785992,2184676.4264790188,361.75472948012811 | -89.1454 | 180 | -0.150442 | -0.0093051081625048649,2.8120093266334825e-10,-0.0079375000014654078 | 0.0093051624679593124,10.922208874914077,0.030573492443412148
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.383Z | Extended Element | 5333575.8605393218,2184676.5748646543,361.7754850463952 | -89.1454 | -180 | -0.0764257 | -0.0093038118739026694,2.1462004394512068e-10,-0.0079375000000568453 | 0.0093038650996267076,10.323271596130006,0.031312112833961292
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.393Z | Extended Element | 5333585.8083118778,2184676.7232505763,361.78242929062509 | -89.1454 | -180 | 0.00992654 | -0.009305097826247298,3.2519395050301764e-10,-0.0079375000002328312 | 0.0093052049219524476,10.922208803466793,0.030684244234209856
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.405Z | Extended Element | 5333595.7560842391,2184676.8716364959,361.77522766067233 | -89.1454 | -180 | 0.0839427 | -0.0079375044749041574,6.6075724654429113e-10,-0.0079375000019011304 | 0.0079374998188037563,10.918954504581158,0.015855031694472128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.455Z | Extended Element | 5333546.0193044925,2184676.00150376,361.67619441411483 | -89.1454 | 180 | -0.2521 | -0.0093047471586866701,7.4875160232198621e-11,-0.0091645189644531874 | 0.0093044071883853427,10.922220028514715,0.025364652598086311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.465Z | Extended Element | 5333555.9669846483,2184676.1498883045,361.71980980470897 | -89.1454 | 180 | -0.236793 | -0.0093038806869239505,2.3281075592732768e-10,-0.0079375000022168934 | 0.0093038072373501889,10.408972711623887,0.0311829069498312
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.476Z | Extended Element | 5333565.9146983689,2184676.2982733496,361.7547294794237 | -89.1454 | 180 | -0.150442 | -0.0093051081625048649,2.8120093266334825e-10,-0.0079375000014654078 | 0.0093051624679593124,10.922208874914077,0.030573492443412148
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.487Z | Extended Element | 5333575.8624516986,2184676.4466589848,361.77548504569523 | -89.1454 | -180 | -0.0764257 | -0.0093038118739026694,2.1462004394512068e-10,-0.0079375000000568453 | 0.0093038650996267076,10.323271596130006,0.031312112833961292
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.497Z | Extended Element | 5333585.8102242565,2184676.5950449067,361.78242928993041 | -89.1454 | -180 | 0.00992654 | -0.009305097826247298,3.2519395050301764e-10,-0.0079375000002328312 | 0.0093052049219524476,10.922208803466793,0.030684244234209856
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.507Z | Extended Element | 5333595.7579966169,2184676.7434308263,361.77522765997844 | -89.1454 | -180 | 0.0839427 | -0.0079375044749041574,6.6075724654429113e-10,-0.0079375000019011304 | 0.0079374998188037563,10.918954504581158,0.015855031694472128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.561Z | Extended Element | 5333546.0193044925,2184676.0015037619,361.50685735573751 | -89.1454 | 179.999 | -0.2521 | -0.0093047471586866701,7.4875160232198621e-11,-0.0091645189644531874 | 0.0093044071883853427,10.922220028514715,0.025364652598086311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.573Z | Extended Element | 5333555.9669846483,2184676.1498883055,361.55047274632471 | -89.1454 | 180 | -0.236793 | -0.0093038806869239505,2.3281075592732768e-10,-0.0079375000022168934 | 0.0093038072373501889,10.408972711623887,0.0311829069498312
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.582Z | Extended Element | 5333565.9146983707,2184676.298273351,361.58539242104519 | -89.1454 | 180 | -0.150442 | -0.0093051081625048649,2.8120093266334825e-10,-0.0079375000014654078 | 0.0093051624679593124,10.922208874914077,0.030573492443412148
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.592Z | Extended Element | 5333575.8624516986,2184676.4466589862,361.60614798731194 | -89.1454 | -180 | -0.0764257 | -0.0093038118739026694,2.1462004394512068e-10,-0.0079375000000568453 | 0.0093038650996267076,10.323271596130006,0.031312112833961292
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.601Z | Extended Element | 5333585.8102242537,2184676.5950449081,361.61309223154973 | -89.1454 | -180 | 0.00992654 | -0.009305097826247298,3.2519395050301764e-10,-0.0079375000002328312 | 0.0093052049219524476,10.922208803466793,0.030684244234209856
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.613Z | Extended Element | 5333595.757996615,2184676.7434308277,361.60589060159799 | -89.1454 | -180 | 0.0839427 | -0.0079375044749041574,6.6075724654429113e-10,-0.0079375000019011304 | 0.0079374998188037563,10.918954504581158,0.015855031694472128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.666Z | Extended Element | 5333546.019076678,2184676.0167767177,361.33752029396987 | -89.1454 | 180 | -0.2521 | -0.0093047471586866701,7.4875160232198621e-11,-0.0091645189644531874 | 0.0093044071883853427,10.922220028514715,0.025364652598086311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.676Z | Extended Element | 5333555.9667568309,2184676.1651612618,361.38113568456185 | -89.1454 | 180 | -0.236793 | -0.0093038806869239505,2.3281075592732768e-10,-0.0079375000022168934 | 0.0093038072373501889,10.408972711623887,0.0311829069498312
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.687Z | Extended Element | 5333565.9144705543,2184676.3135463074,361.41605535928073 | -89.1454 | 180 | -0.150442 | -0.0093051081625048649,2.8120093266334825e-10,-0.0079375000014654078 | 0.0093051624679593124,10.922208874914077,0.030573492443412148
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.697Z | Extended Element | 5333575.8622238841,2184676.4619319434,361.43681092554948 | -89.1454 | -180 | -0.0764257 | -0.0093038118739026694,2.1462004394512068e-10,-0.0079375000000568453 | 0.0093038650996267076,10.323271596130006,0.031312112833961292
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.707Z | Extended Element | 5333585.8099964429,2184676.6103178649,361.44375516978448 | -89.1454 | -180 | 0.00992654 | -0.009305097826247298,3.2519395050301764e-10,-0.0079375000002328312 | 0.0093052049219524476,10.922208803466793,0.030684244234209856
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.717Z | Extended Element | 5333595.7577688014,2184676.7587037846,361.4365535398332 | -89.1454 | 180 | 0.0839427 | -0.0079375044749041574,6.6075724654429113e-10,-0.0079375000019011304 | 0.0079374998188037563,10.918954504581158,0.015855031694472128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.775Z | Extended Element | 5333546.0193044934,2184676.0015037586,361.05811973831641 | -89.1454 | 180 | -0.2521 | -0.0093047471586866701,7.4875160232198621e-11,-0.0091645189644531874 | 0.0093044071883853427,10.922220028514715,0.025364652598086311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.783Z | Extended Element | 5333555.9669846483,2184676.1498883031,361.10173512890253 | -89.1454 | 180 | -0.236793 | -0.0093038806869239505,2.3281075592732768e-10,-0.0079375000022168934 | 0.0093038072373501889,10.408972711623887,0.0311829069498312
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.791Z | Extended Element | 5333565.9146983698,2184676.2982733478,361.13665480363545 | -89.1454 | 180 | -0.150442 | -0.0093051081625048649,2.8120093266334825e-10,-0.0079375000014654078 | 0.0093051624679593124,10.922208874914077,0.030573492443412148
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.799Z | Extended Element | 5333575.8624516986,2184676.4466589834,361.15741036990931 | -89.1454 | -180 | -0.0764257 | -0.0093038118739026694,2.1462004394512068e-10,-0.0079375000000568453 | 0.0093038650996267076,10.323271596130006,0.031312112833961292
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.810Z | Extended Element | 5333585.8102242537,2184676.5950449058,361.16435461415045 | -89.1454 | -180 | 0.00992654 | -0.009305097826247298,3.2519395050301764e-10,-0.0079375000002328312 | 0.0093052049219524476,10.922208803466793,0.030684244234209856
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.821Z | Extended Element | 5333595.757996616,2184676.7434308254,361.1571529842044 | -89.1454 | 180 | 0.0839427 | -0.0079375044749041574,6.6075724654429113e-10,-0.0079375000019011304 | 0.0079374998188037563,10.918954504581158,0.015855031694472128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.876Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333606.3416089835,2184677.2612745287,360.73956934656752 | 5333611.0247611757,2184690.7462798627,361.15128450671506
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.889Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333551.0178245474,2184689.8331246763,360.70823836635043 | 5333551.0250224629,2184690.3156719534,360.97922642777189
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.897Z | Line | 5333611.0162274353,2184691.0582207101,361.01654831021125 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,0.00018253337805163028
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.924Z | Line | 5333550.9742280105,2184689.8323670104,360.97922636254128 | 0 | 0 | 0 | 0,-0.016660743393003941,0 | 0.047990310937166214,0,9.0949470177292824e-13
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.938Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333546.3406955097,2184676.3323629065,360.68083559563894 | 5333551.0230229916,2184689.8165109297,361.09488558144307
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:28.949Z | Line | 5333550.9742280049,2184689.8323669932,360.97922636254174 | 0 | 0 | 0 | 0,0,0 | 0.050794452428817749,0.00075767561793327332,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.358Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333546.3439019863,2184675.8672340335,360.68635836540801 | 5333611.0215546982,2184691.211433575,361.01738527468387
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.410Z | Line | 5333550.9742280049,2184689.8323669932,360.97922636254174 | 0 | 0 | 0 | 0,-13.409735058899969,-1.8619882098391827e-06 | 0.20002627931535244,0,0
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.418Z | Bspline Curve | 5333550.9742280049,2184689.8323669932,360.97922636254185 | 0 | 0 | 0 | 0,0,0 | 60.097718810662627,0.89644745970144868,0.083478415948538887
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.429Z | Bspline Curve | 5333546.2935098698,2184676.349828322,360.9577487634034 | 0 | 0 | 0 | 0,0,0 | 60.097718810662627,0.89644746063277125,0.10495601508698879
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.447Z | Line | 5333551.0742411446,2184683.1274994463,361.10457567879132 | 0 | 0 | 0 | -9.3132257461547852e-10,0,-0.07937515875033796 | 0,1.0710209608078003e-08,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.458Z | Line String | 5333551.0742410617,2184683.1274994733,361.02520051941929 | 0 | 0 | 0 | 0,0,0 | 55.216974477283657,0.82364385109394789,0.083478351095550352
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.467Z | Line | 5333606.291215538,2184683.9511433244,361.07844259777755 | 0 | 0 | 0 | 0,-2.3283064365386963e-09,0 | 0,0,0.07937515875033796
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.477Z | Line | 5333610.0448299721,2184691.1961481203,361.02010460559359 | 0 | 0 | 0 | 0,0,-0.25400050800112695 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.489Z | Line | 5333550.9742280049,2184689.8323669932,360.97922636254174 | 0 | 0 | 0 | -9.3132257461547852e-10,0,-0.07937515875033796 | 0,9.7788870334625244e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.498Z | Complex Chain | 5333550.9677878581,2184690.2641198509,360.81095206383941 | 0 | 0 | 0 | 0,-14.273240728769451,-1.9445944872131804e-06 | 0.21290657948702574,0,0.12534829916211265
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.509Z | Line | 5333551.0742411437,2184683.1274994458,361.10457567879132 | 0 | 0 | 0 | 0,0,-0.16827533655077787 | 3.7252902984619141e-09,2.2351741790771484e-08,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.518Z | Line String | 5333551.074241166,2184683.1274994873,360.93630034183059 | 0 | 0 | 0 | 0,0,0 | 55.216974367387593,0.82364384876564145,0.08347835065393383
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.530Z | Line | 5333606.291215538,2184683.951143322,361.15781775652789 | 0 | 0 | 0 | 0,0,-0.16827533655066418 | 3.7252902984619141e-09,2.1886080503463745e-08,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.560Z | Extended Element | 5333551.4110517204,2184675.9943152457,360.8119638040373 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.571Z | Extended Element | 5333551.6904184949,2184675.9984824196,360.81319315459655 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.581Z | Extended Element | 5333551.9697852731,2184676.0026495932,360.81442250515556 | 0.854588 | 0.0000104129 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.591Z | Extended Element | 5333552.2491520485,2184676.0068167672,360.81565185571463 | 0.854588 | 0.00000408648 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.600Z | Extended Element | 5333552.3156122454,2184690.2842246694,360.81688315086831 | -179.145 | 0.00000919019 | -0.00000317347 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.611Z | Extended Element | 5333552.5949790208,2184690.288391843,360.81811250142744 | -179.145 | 0.00000919019 | -0.00000317347 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.622Z | Extended Element | 5333552.874345798,2184690.2925590165,360.81934185198656 | -179.145 | 0.00000244268 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.632Z | Extended Element | 5333553.1537125735,2184690.296726191,360.82057120254564 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.640Z | Extended Element | 5333553.4330793517,2184690.300893364,360.82180055310477 | -179.145 | 0.00000924085 | -0.00000819555 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.650Z | Extended Element | 5333553.7124461262,2184690.305060538,360.82302990366384 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.660Z | Extended Element | 5333554.2047194811,2184676.0359869832,360.82425730962842 | 0.854588 | 0.0000035676 | 0.00000821965 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.668Z | Extended Element | 5333554.4840862574,2184676.0401541567,360.82548666018738 | 0.854588 | 0.00000403577 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.685Z | Extended Element | 5333554.5505465167,2184690.3175620595,360.82670334544048 | -179.145 | 0.00000871848 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.697Z | Extended Element | 5333555.0428199722,2184676.048488507,360.82790846894881 | 0.854588 | 0.0000103658 | 0.00000806984 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.705Z | Extended Element | 5333555.3221868435,2184676.0526556815,360.82911553705145 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.714Z | Extended Element | 5333555.3886471363,2184690.3300635861,360.83032454974881 | -179.145 | 0.00000239198 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.729Z | Extended Element | 5333555.6680141464,2184690.3342307638,360.83149943325901 | -179.145 | 0.00000244268 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.740Z | Extended Element | 5333555.9473812412,2184690.3383979416,360.8326541415629 | -179.145 | 0.00000239198 | -0.0000080457 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.748Z | Extended Element | 5333556.4396549156,2184676.0693243919,360.8338069052723 | 0.854588 | 0.00000356758 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.758Z | Extended Element | 5333556.50611543,2184690.3467322979,360.8349635581709 | -179.145 | 0.00000239198 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.767Z | Extended Element | 5333556.9983891062,2184676.0776587492,360.83611632188035 | 0.854588 | 0.00000403929 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.785Z | Extended Element | 5333557.2777562374,2184676.0818259274,360.83726140004865 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.798Z | Extended Element | 5333557.3442169959,2184690.359233838,360.83835789818352 | -179.145 | 0.00000919019 | -0.00000302363 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.808Z | Extended Element | 5333557.6235843329,2184690.3634010204,360.83945245172362 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.816Z | Extended Element | 5333558.1158582475,2184676.094327474,360.8405450606694 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.827Z | Extended Element | 5333558.3952255836,2184676.0984946564,360.84163961420973 | 0.854588 | 0.0000103658 | 0.00000806984 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.838Z | Extended Element | 5333558.461686343,2184690.3759025671,360.84273611234454 | -179.145 | 0.00000919019 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.854Z | Extended Element | 5333558.7410538401,2184690.3800697508,360.84378822647102 | -179.145 | 0.00000239199 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.864Z | Extended Element | 5333559.2333279876,2184676.1109962086,360.84482068050187 | 0.854588 | 0.00000408648 | 0.00000304777 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.875Z | Extended Element | 5333559.2997889724,2184690.3884041226,360.84585702372181 | -179.145 | 0.00000913949 | -0.00000302363 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.885Z | Extended Element | 5333559.5791565375,2184690.3925713082,360.84689142234726 | -179.145 | 0.00000244268 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.897Z | Extended Element | 5333560.0714306822,2184676.1234977655,360.84792387637805 | 0.854588 | 0.0000103657 | 0.00000319826 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.914Z | Extended Element | 5333560.3507983033,2184676.1276649516,360.8489431809445 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.925Z | Extended Element | 5333560.6301660873,2184676.131832141,360.84991742450848 | 0.854588 | 0.00000398861 | 0.00000822096 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.935Z | Extended Element | 5333560.9095338676,2184676.1359993294,360.85089166807268 | 0.854588 | 0.0000103657 | 0.0000030484 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.943Z | Extended Element | 5333561.1889016498,2184676.1401665183,360.85186591163688 | 0.854588 | 0.0000103151 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.951Z | Extended Element | 5333561.468269431,2184676.1443337062,360.85284015520074 | 0.854588 | 0.00000403579 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.960Z | Extended Element | 5333561.5347306347,2184690.4217416239,360.85381634335943 | -179.145 | 0.00000923734 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.977Z | Extended Element | 5333561.8140985789,2184690.4259088156,360.85474268290204 | -179.145 | 0.00000924085 | -0.00000819555 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.988Z | Extended Element | 5333562.3063731417,2184676.156835278,360.85565482667732 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:29.996Z | Extended Element | 5333562.5857411278,2184676.1610024697,360.85656891504715 | 0.854588 | 0.00000403577 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.007Z | Extended Element | 5333562.6522025336,2184690.4384103906,360.8574849480114 | -179.145 | 0.00000244268 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.016Z | Extended Element | 5333563.1444770992,2184676.1693368535,360.8583970917868 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.035Z | Extended Element | 5333563.4238451486,2184676.1735040466,360.85929062111677 | 0.854588 | 0.00000403931 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.046Z | Extended Element | 5333563.4903067444,2184690.4509119699,360.86014649875796 | -179.145 | 0.00000243917 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.057Z | Extended Element | 5333563.7696749205,2184690.4550791644,360.86100043180454 | -179.145 | 0.00000913949 | -0.00000317284 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.066Z | Extended Element | 5333564.2619496761,2184676.1860056305,360.86185242025653 | 0.854588 | 0.0000035676 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.077Z | Extended Element | 5333564.3284112737,2184690.4634135538,360.86270829789765 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.085Z | Extended Element | 5333564.8206860283,2184676.194340019,360.86356028634964 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.099Z | Extended Element | 5333565.10005436,2184676.1985072163,360.8643608497909 | 0.854588 | 0.0000103657 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.111Z | Extended Element | 5333565.1665161345,2184690.4759151419,360.86515657199169 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.121Z | Extended Element | 5333565.4458844876,2184690.4800823387,360.86595034959805 | -179.145 | 0.00000919015 | -0.0000080457 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.131Z | Extended Element | 5333565.9381594192,2184676.2110088081,360.86674218260976 | 0.854588 | 0.00000408648 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.141Z | Extended Element | 5333566.2175277723,2184676.2151760058,360.86753596021589 | 0.854588 | 0.00000403929 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.160Z | Extended Element | 5333566.4968961962,2184676.2193432041,360.86830371287476 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.169Z | Extended Element | 5333566.7762647141,2184676.2235104046,360.86903733492903 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.180Z | Extended Element | 5333567.0556332301,2184676.2276776037,360.86977095698342 | 0.854588 | 0.0000103658 | 0.00000806984 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.190Z | Extended Element | 5333567.3350017481,2184676.2318448033,360.8705045790378 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.201Z | Extended Element | 5333567.4014636874,2184690.5092527322,360.87124014568667 | -179.145 | 0.00000919015 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.211Z | Extended Element | 5333567.6808322035,2184690.5134199308,360.87197376774111 | -179.145 | 0.00000239198 | -0.00000804569 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.229Z | Extended Element | 5333567.9602008676,2184690.5175871332,360.87264855376043 | -179.145 | 0.00000244268 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.241Z | Extended Element | 5333568.4524761168,2184676.2485136064,360.87332007556654 | 0.854588 | 0.00000403579 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.250Z | Extended Element | 5333568.7318447866,2184676.2526808083,360.87399354196748 | 0.854588 | 0.0000035676 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.260Z | Extended Element | 5333569.0112134535,2184676.2568480112,360.87466700836825 | 0.854588 | 0.00000356758 | 0.00000319758 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.269Z | Extended Element | 5333569.2905821241,2184676.2610152126,360.87534047476913 | 0.854588 | 0.00000361477 | 0.00000304777 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.287Z | Extended Element | 5333569.5699508665,2184676.2651824169,360.87598244951806 | 0.854588 | 0.0000104129 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.297Z | Extended Element | 5333569.6364130937,2184690.5425903485,360.87659770476625 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.309Z | Extended Element | 5333570.1286884807,2184676.2735168245,360.87720907082547 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.319Z | Extended Element | 5333570.4080572873,2184676.2776840287,360.87782238147918 | 0.854588 | 0.0000103658 | 0.00000821969 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.329Z | Extended Element | 5333570.687426094,2184676.2818512321,360.87843569213277 | 0.854588 | 0.0000103657 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.346Z | Extended Element | 5333570.966794909,2184676.2860184363,360.87904485544055 | 0.854588 | 0.0000103622 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.359Z | Extended Element | 5333571.2461638432,2184676.290185642,360.87959801026176 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.368Z | Extended Element | 5333571.5255327765,2184676.2943528481,360.88015116508302 | 0.854588 | 0.00000403931 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.382Z | Extended Element | 5333571.5919951303,2184690.5717607825,360.88070626449883 | -179.145 | 0.00000919015 | -0.0000080457 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.393Z | Extended Element | 5333572.0842706412,2184676.3026872603,360.88125747472526 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.401Z | Extended Element | 5333572.3636395754,2184676.306854465,360.88181062954652 | 0.854588 | 0.00000403579 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.416Z | Extended Element | 5333572.6430085776,2184676.3110216726,360.88232682534596 | 0.854588 | 0.0000103658 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.426Z | Extended Element | 5333572.9223776218,2184676.3151888801,360.88281982425849 | 0.854588 | 0.0000103657 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.435Z | Extended Element | 5333573.2017466677,2184676.3193560881,360.88331282317091 | 0.854588 | 0.00000398861 | 0.00000822031 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.444Z | Extended Element | 5333573.2682091333,2184690.5967640243,360.88380776667805 | -179.145 | 0.0000091902 | -0.00000302299 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.456Z | Extended Element | 5333573.7604847606,2184676.3276905036,360.88429882099604 | 0.854588 | 0.00000403929 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.474Z | Extended Element | 5333573.826947242,2184690.6050984403,360.88478414957535 | -179.145 | 0.00000919015 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.484Z | Extended Element | 5333574.3192229671,2184676.3360249209,360.88521504791436 | 0.854588 | 0.0000035676 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.495Z | Extended Element | 5333574.5985921109,2184676.3401921294,360.88564789084791 | 0.854588 | 0.0000103657 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.507Z | Extended Element | 5333574.6650546761,2184690.6176000675,360.886082678376 | -179.145 | 0.00000919019 | -0.00000317347 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.516Z | Extended Element | 5333575.1573304022,2184676.3485265472,360.88651357671512 | 0.854588 | 0.00000408648 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.527Z | Extended Element | 5333575.4366995478,2184676.3526937561,360.88694641964867 | 0.854588 | 0.00000356408 | 0.00000821966 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.544Z | Extended Element | 5333575.7160687521,2184676.3568609669,360.88733683565471 | 0.854588 | 0.00000403929 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.555Z | Extended Element | 5333575.9954379844,2184676.3610281772,360.88770952255044 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.565Z | Extended Element | 5333576.0619006371,2184690.6384361167,360.88808415404065 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.577Z | Extended Element | 5333576.3412698694,2184690.6426033266,360.88845684093633 | -179.145 | 0.00000919015 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.586Z | Extended Element | 5333576.8335456811,2184676.3735298091,360.88882758323757 | 0.854588 | 0.0000035676 | 0.00000806982 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.603Z | Extended Element | 5333576.9000083506,2184690.6509377477,360.88918713173268 | -179.145 | 0.00000919015 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.615Z | Extended Element | 5333577.3922842368,2184676.3818642306,360.8894977179437 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.626Z | Extended Element | 5333577.6716535417,2184676.3860314419,360.88981024874914 | 0.854588 | 0.00000403577 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.636Z | Extended Element | 5333577.9510228485,2184676.3901986536,360.8901227795547 | 0.854588 | 0.0000103657 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.646Z | Extended Element | 5333578.2303921524,2184676.3943658643,360.89043531036015 | 0.854588 | 0.00000403579 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.658Z | Extended Element | 5333578.2968548797,2184690.6717738048,360.89074978576025 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.675Z | Extended Element | 5333578.7891308125,2184676.4027002892,360.8910124767346 | 0.854588 | 0.00000403929 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.684Z | Extended Element | 5333578.8555935994,2184690.6801082301,360.89126679600145 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.695Z | Extended Element | 5333579.1349629667,2184690.6842754423,360.89151917067386 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.706Z | Extended Element | 5333579.414332334,2184690.6884426544,360.89177154534616 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.716Z | Extended Element | 5333579.6937016994,2184690.6926098666,360.89202392001852 | -179.145 | 0.00000913949 | -0.00000317347 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.732Z | Extended Element | 5333579.9730710825,2184690.6967770797,360.8922557432727 | -179.145 | 0.00000244268 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.744Z | Extended Element | 5333580.4653470749,2184676.4277035645,360.89244601718178 | 0.854588 | 0.00000403931 | 0.00000821967 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.753Z | Extended Element | 5333580.7447164916,2184676.4318707776,360.8926382356853 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.764Z | Extended Element | 5333581.0240859054,2184676.4360379903,360.89283045418887 | 0.854588 | 0.00000403929 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.776Z | Extended Element | 5333581.3034553193,2184676.4402052038,360.89302267269255 | 0.854588 | 0.00000403929 | 0.00000304839 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.785Z | Extended Element | 5333581.3699181527,2184690.7176131452,360.89321683579078 | -179.145 | 0.00000918668 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.803Z | Extended Element | 5333581.8621941777,2184676.44853963,360.89335374588018 | 0.854588 | 0.0000103657 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.814Z | Extended Element | 5333581.9286570475,2184690.7259475719,360.89348775278319 | -179.145 | 0.00000913949 | -0.00000317347 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.826Z | Extended Element | 5333582.4209330762,2184676.4568740572,360.89361787049705 | 0.854588 | 0.00000356407 | 0.0000031976 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.838Z | Extended Element | 5333582.4873959459,2184690.7342820005,360.89375187740006 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.847Z | Extended Element | 5333582.9796719747,2184676.4652084853,360.89388199511382 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.865Z | Extended Element | 5333583.2590414351,2184676.4693756984,360.89398803735662 | 0.854588 | 0.00000403577 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.877Z | Extended Element | 5333583.5384109057,2184676.4735429124,360.89405994345145 | 0.854588 | 0.00000408648 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.886Z | Extended Element | 5333583.6048737969,2184690.7509508547,360.89413379414088 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.899Z | Extended Element | 5333583.8842432676,2184690.7551180688,360.89420570023572 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
