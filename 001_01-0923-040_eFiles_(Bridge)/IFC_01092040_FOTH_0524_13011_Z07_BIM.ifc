Properties of the parts of a building model (IFC4X3_ADD2), part 7 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.005Z | Extended Element | 5333559.5651768204,2184689.2454816038,360.81352822953693 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.016Z | Extended Element | 5333559.8699414395,2184689.2500276249,360.81465666440101 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.032Z | Extended Element | 5333560.1747061247,2184689.254573646,360.81576576094619 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.042Z | Extended Element | 5333560.4794709785,2184689.2591196699,360.8168285721087 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.053Z | Extended Element | 5333560.7842358332,2184689.2636656943,360.81789138326718 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.061Z | Extended Element | 5333561.0890006861,2184689.2682117186,360.81895419443003 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.073Z | Extended Element | 5333561.3937655389,2184689.2727577426,360.82001700559016 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.091Z | Extended Element | 5333561.698530457,2184689.2773037674,360.82106048038474 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.103Z | Extended Element | 5333562.0032955306,2184689.281849795,360.82205766769744 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.114Z | Extended Element | 5333562.3080606069,2184689.2863958222,360.82305485501001 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.123Z | Extended Element | 5333562.6128256796,2184689.2909418494,360.82405204232384 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.135Z | Extended Element | 5333562.917590756,2184689.295487877,360.82504922963756 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.153Z | Extended Element | 5333563.222355892,2184689.3000339051,360.82602708230047 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.162Z | Extended Element | 5333563.5271211751,2184689.3045799355,360.82695864562004 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.174Z | Extended Element | 5333563.8318864582,2184689.3091259669,360.82789020894427 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.186Z | Extended Element | 5333564.1366517395,2184689.3136719968,360.82882177226668 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.197Z | Extended Element | 5333564.4414170226,2184689.3182180268,360.82975333558932 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.218Z | Extended Element | 5333564.7461823598,2184689.3227640591,360.83066556575835 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.227Z | Extended Element | 5333565.0509478385,2184689.3273100914,360.83153150496355 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.238Z | Extended Element | 5333565.3557133162,2184689.331856126,360.83239744417187 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.249Z | Extended Element | 5333565.6604787912,2184689.3364021583,360.83326338337565 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.259Z | Extended Element | 5333565.9652442671,2184689.3409481919,360.83412932258625 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.277Z | Extended Element | 5333566.2700097961,2184689.3454942261,360.83497592992313 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.289Z | Extended Element | 5333566.574775449,2184689.3500402621,360.83577624489129 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.301Z | Extended Element | 5333566.8795411056,2184689.3545862981,360.83657655986025 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.311Z | Extended Element | 5333567.1843067594,2184689.3591323346,360.83737687482869 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.322Z | Extended Element | 5333567.489072416,2184689.3636783706,360.83817718979736 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.336Z | Extended Element | 5333567.7938381182,2184689.3682244071,360.83895817399565 | 0.854589 | -1.59125e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.345Z | Extended Element | 5333568.0986039415,2184689.3727704459,360.83969286461365 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.355Z | Extended Element | 5333568.403369762,2184689.3773164847,360.84042755523615 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.365Z | Extended Element | 5333568.7081355825,2184689.381862524,360.84116224585443 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.376Z | Extended Element | 5333569.012901403,2184689.3864085628,360.84189693647517 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.393Z | Extended Element | 5333569.3176672654,2184689.3909546011,360.84261229724666 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.404Z | Extended Element | 5333569.6224332387,2184689.3955006418,360.84328136341509 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.415Z | Extended Element | 5333569.9271992091,2184689.4000466834,360.84395042958181 | 0.854589 | -6.90396e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.425Z | Extended Element | 5333570.2319651814,2184689.4045927236,360.84461949574973 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.436Z | Extended Element | 5333570.5367311547,2184689.4091387643,360.84528856191594 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.455Z | Extended Element | 5333570.8414971652,2184689.4136848054,360.84593829900058 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.467Z | Extended Element | 5333571.1462632734,2184689.4182308489,360.84654174062359 | 0.854589 | -6.89321e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.477Z | Extended Element | 5333571.4510293808,2184689.4227768918,360.84714518224791 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.489Z | Extended Element | 5333571.7557954919,2184689.4273229344,360.84774862387098 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.502Z | Extended Element | 5333572.0605616001,2184689.4318689769,360.8483520654936 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.517Z | Extended Element | 5333572.3653277447,2184689.4364150213,360.84893617864969 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.526Z | Extended Element | 5333572.670093976,2184689.4409610652,360.8494739956451 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.534Z | Extended Element | 5333572.9748602072,2184689.4455071106,360.85001181264141 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.544Z | Extended Element | 5333573.2796264403,2184689.450053155,360.85054962963676 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.553Z | Extended Element | 5333573.5843926687,2184689.4545991994,360.85108744663057 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.571Z | Extended Element | 5333573.8891589344,2184689.4591452447,360.85160593564984 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.581Z | Extended Element | 5333574.1939252736,2184689.46369129,360.85207812793914 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.592Z | Extended Element | 5333574.4986916138,2184689.4682373367,360.8525503202315 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.603Z | Extended Element | 5333574.8034579549,2184689.472783383,360.85302251252199 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.614Z | Extended Element | 5333575.1082242951,2184689.4773294292,360.85349470481276 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.631Z | Extended Element | 5333575.4129906632,2184689.481875475,360.85394756950211 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.640Z | Extended Element | 5333575.7177570984,2184689.4864215236,360.85435413702714 | 0.854589 | -6.90396e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.648Z | Extended Element | 5333576.0225235326,2184689.4909675713,360.85476070455098 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.657Z | Extended Element | 5333576.3272899669,2184689.4955136185,360.85516727207056 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.667Z | Extended Element | 5333576.6320564039,2184689.5000596666,360.85557383959406 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.685Z | Extended Element | 5333576.9368228596,2184689.5046057147,360.85596107979109 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.694Z | Extended Element | 5333577.2415893758,2184689.5091517637,360.85630202248717 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.704Z | Extended Element | 5333577.546355891,2184689.5136978128,360.85664296518593 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.714Z | Extended Element | 5333577.8511224063,2184689.5182438609,360.85698390788269 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.724Z | Extended Element | 5333578.1558889216,2184689.5227899104,360.85732485058134 | 0.854589 | -6.89321e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.740Z | Extended Element | 5333578.4606554555,2184689.527335959,360.85764646614217 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.753Z | Extended Element | 5333578.7654220378,2184689.5318820095,360.85792178396707 | 0.854589 | -6.90396e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.761Z | Extended Element | 5333579.0701886201,2184689.5364280595,360.85819710179089 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.774Z | Extended Element | 5333579.3749552006,2184689.5409741094,360.85847241961346 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.784Z | Extended Element | 5333579.6797217829,2184689.5455201594,360.85874773743672 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.801Z | Extended Element | 5333579.9844883811,2184689.5500662094,360.85900372824887 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.810Z | Extended Element | 5333580.2892550128,2184689.5546122598,360.85921342116245 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.822Z | Extended Element | 5333580.5940216463,2184689.5591583108,360.85942311407644 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.833Z | Extended Element | 5333580.8987882808,2184689.5637043612,360.85963280698758 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.843Z | Extended Element | 5333581.2035549134,2184689.5682504131,360.85984249990253 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.862Z | Extended Element | 5333581.5083215591,2184689.5727964635,360.86003286587231 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.871Z | Extended Element | 5333581.8130882327,2184689.5773425135,360.86017693384116 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.879Z | Extended Element | 5333582.1178549025,2184689.5818885658,360.86032100181637 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.888Z | Extended Element | 5333582.422621578,2184689.5864346167,360.86046506978909 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.899Z | Extended Element | 5333582.727388246,2184689.5909806681,360.86060913776475 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.914Z | Extended Element | 5333583.0321549252,2184689.595526719,360.86073387882317 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.924Z | Extended Element | 5333583.336921622,2184689.6000727708,360.86081232183477 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.934Z | Extended Element | 5333583.6416883189,2184689.6046188222,360.86089076484677 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.944Z | Extended Element | 5333583.946455013,2184689.6091648741,360.86096920786093 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.954Z | Extended Element | 5333584.251221709,2184689.6137109259,360.86104765087197 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.968Z | Extended Element | 5333584.5559884068,2184689.6182569773,360.86110971121298 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.977Z | Extended Element | 5333584.8607551139,2184689.6228030291,360.86113252647914 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.987Z | Extended Element | 5333585.1655218164,2184689.6273490805,360.86115534174115 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:21.998Z | Extended Element | 5333585.4702885235,2184689.6318951319,360.86117815700658 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.016Z | Extended Element | 5333585.7750552297,2184689.6364411842,360.86117413519099 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.031Z | Extended Element | 5333586.079821934,2184689.6409872356,360.86115153027868 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.039Z | Extended Element | 5333586.3845886327,2184689.6455332879,360.86109872334885 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.050Z | Extended Element | 5333586.6893553352,2184689.6500793393,360.86104591641703 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.058Z | Extended Element | 5333586.9941220377,2184689.6546253911,360.86099310948515 | 0.854589 | -1.59233e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.069Z | Extended Element | 5333587.2988887392,2184689.6591714425,360.86094030255413 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.087Z | Extended Element | 5333587.6036554342,2184689.6637174939,360.86086816872444 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.098Z | Extended Element | 5333587.9084221171,2184689.6682635457,360.86074973682651 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.109Z | Extended Element | 5333588.2131887991,2184689.6728095971,360.86063130492875 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.120Z | Extended Element | 5333588.517955482,2184689.6773556489,360.86051287303161 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.131Z | Extended Element | 5333588.8227221668,2184689.6819016999,360.86039444113487 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.148Z | Extended Element | 5333589.1274888385,2184689.6864477512,360.86025668236596 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.158Z | Extended Element | 5333589.4322554888,2184689.6909938022,360.8600726255209 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.170Z | Extended Element | 5333589.737022141,2184689.6955398535,360.85988856867374 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.182Z | Extended Element | 5333590.0417887876,2184689.7000859031,360.85970451182521 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.191Z | Extended Element | 5333590.3465554407,2184689.7046319544,360.85952045497982 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.209Z | Extended Element | 5333590.651322078,2184689.7091780053,360.85931707133187 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.221Z | Extended Element | 5333590.9560886808,2184689.7137240558,360.8590673895626 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.232Z | Extended Element | 5333591.2608552845,2184689.7182701048,360.85881770779014 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.242Z | Extended Element | 5333591.5656218873,2184689.7228161558,360.8585680260212 | 0.854589 | -6.89321e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.254Z | Extended Element | 5333591.8703884911,2184689.7273622057,360.85831834425102 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.273Z | Extended Element | 5333592.1751550753,2184689.7319082557,360.85804933579993 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.283Z | Extended Element | 5333592.4799216203,2184689.7364543057,360.85773402914157 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.293Z | Extended Element | 5333592.7846881626,2184689.7410003548,360.85741872248093 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.303Z | Extended Element | 5333593.0894547049,2184689.7455464033,360.85710341582217 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.311Z | Extended Element | 5333593.3942212472,2184689.7500924543,360.85678810916357 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.326Z | Extended Element | 5333593.6989877699,2184689.7546385028,360.85645347601115 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.339Z | Extended Element | 5333594.0037542377,2184689.759184551,360.85607254450667 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.349Z | Extended Element | 5333594.3085207054,2184689.7637305986,360.85569161300276 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.358Z | Extended Element | 5333594.6132871732,2184689.7682766472,360.85531068149669 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.369Z | Extended Element | 5333594.9180536401,2184689.7728226949,360.85492974999494 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.387Z | Extended Element | 5333595.2228200827,2184689.7773687434,360.85452949227022 | 0.854589 | -1.59233e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.397Z | Extended Element | 5333595.527586462,2184689.7819147897,360.85408293597487 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.409Z | Extended Element | 5333595.8323528413,2184689.7864608373,360.85363637967771 | 0.854589 | -1.59233e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.420Z | Extended Element | 5333596.1371192196,2184689.7910068836,360.85318982337958 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.429Z | Extended Element | 5333596.441885598,2184689.7955529313,360.85274326708497 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.450Z | Extended Element | 5333596.7466519475,2184689.8000989771,360.85227738493592 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.459Z | Extended Element | 5333597.0514182216,2184689.8046450228,360.85176520391116 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.471Z | Extended Element | 5333597.3561844984,2184689.8091910677,360.85125302288645 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.481Z | Extended Element | 5333597.6609507734,2184689.8137371135,360.85074084186061 | 0.854589 | -6.89321e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.492Z | Extended Element | 5333597.9657170502,2184689.8182831584,360.85022866083256 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.510Z | Extended Element | 5333598.2704832908,2184689.8228292032,360.8496971544422 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.522Z | Extended Element | 5333598.5752494475,2184689.8273752462,360.84911934875618 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.533Z | Extended Element | 5333598.8800156079,2184689.8319212906,360.84854154306959 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.544Z | Extended Element | 5333599.1847817656,2184689.8364673336,360.84796373738612 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.555Z | Extended Element | 5333599.4895479232,2184689.8410133771,360.84738593170061 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.574Z | Extended Element | 5333599.7943140436,2184689.8455594201,360.84678880126222 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.585Z | Extended Element | 5333600.0990800709,2184689.8501054621,360.84614537099816 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.594Z | Extended Element | 5333600.4038460962,2184689.8546515037,360.84550194073529 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.608Z | Extended Element | 5333600.7086121226,2184689.8591975453,360.84485851047179 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.619Z | Extended Element | 5333601.0133781508,2184689.8637435865,360.84421508020677 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.636Z | Extended Element | 5333601.3181441352,2184689.8682896276,360.8435523259464 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.648Z | Extended Element | 5333601.6229100162,2184689.8728356669,360.84284327119474 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.657Z | Extended Element | 5333601.9276758973,2184689.8773817061,360.84213421644279 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.665Z | Extended Element | 5333602.2324417774,2184689.8819277454,360.84142516168862 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.675Z | Extended Element | 5333602.5372076593,2184689.8864737852,360.84071610693815 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.691Z | Extended Element | 5333602.8419734929,2184689.8910198254,360.83998772910547 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.703Z | Extended Element | 5333603.1467392156,2184689.8955658618,360.83921304996386 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.712Z | Extended Element | 5333603.4515049355,2184689.9001118988,360.83843837081969 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.724Z | Extended Element | 5333603.7562706582,2184689.9046579362,360.83766369167995 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.738Z | Extended Element | 5333604.0610363781,2184689.9092039722,360.8368890125368 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.756Z | Extended Element | 5333604.3658020487,2184689.9137500091,360.83609501140683 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.767Z | Extended Element | 5333604.6705675973,2184689.9182960433,360.8352547079819 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.776Z | Extended Element | 5333604.9753331449,2184689.9228420784,360.83441440455721 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.787Z | Extended Element | 5333605.2800986934,2184689.927388113,360.83357410113319 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.799Z | Extended Element | 5333605.5848642411,2184689.9319341471,360.83273379770731 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.816Z | Extended Element | 5333605.8896297347,2184689.9364801813,360.83187417357891 | 0.854589 | -1.73646e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.824Z | Extended Element | 5333606.1943950932,2184689.9410262126,360.830968245988 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.835Z | Extended Element | 5333606.4991604527,2184689.945572244,360.83006231839749 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.844Z | Extended Element | 5333606.8039258113,2184689.9501182749,360.82915639080551 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.856Z | Extended Element | 5333607.1086911717,2184689.9546643076,360.82825046321472 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.874Z | Extended Element | 5333607.4134564716,2184689.9592103385,360.82732521640429 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.884Z | Extended Element | 5333607.7182216281,2184689.9637563666,360.82635366477479 | 0.854589 | -6.82594e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.892Z | Extended Element | 5333608.0229867864,2184689.9683023957,360.82538211314511 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.904Z | Extended Element | 5333608.3277519448,2184689.9728484238,360.82441056151345 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.913Z | Extended Element | 5333608.6325171022,2184689.9773944523,360.82343900988366 | 0.854589 | -1.58452e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.932Z | Extended Element | 5333608.9372821962,2184689.9819404799,360.82244814073971 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.942Z | Extended Element | 5333609.2420471394,2184689.9864865057,360.82141096520451 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.953Z | Extended Element | 5333609.5468120789,2184689.9910325306,360.820373789668 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.963Z | Extended Element | 5333609.8515770193,2184689.9955785563,360.81933661413234 | 0.854589 | -1.73538e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.974Z | Extended Element | 5333610.1563419625,2184690.0001245821,360.81829943859742 | 0.854589 | -1.72866e-07 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:22.989Z | Extended Element | 5333547.0288528744,2184675.9278552262,360.95978293483029 | 0 | 0 | 0 | -6.8424163904290403e-12,-4.2331020958484566e-10,1.2682563332866437e-14 | 58.633473035607508,1.308640819106027,1.0689401204813316
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.010Z | Extended Element | 5333547.2426345488,2184676.003582614,360.98730177545121 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.019Z | Extended Element | 5333547.5473983036,2184676.0081286216,360.98864288515165 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.029Z | Extended Element | 5333547.8521620585,2184676.0126746297,360.98998399485208 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.038Z | Extended Element | 5333548.1569258152,2184676.0172206368,360.99132510455246 | -179.145 | -1.09758e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.050Z | Extended Element | 5333548.4616895709,2184676.0217666449,360.99266621425295 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.059Z | Extended Element | 5333548.7664533267,2184676.0263126525,360.99400732395327 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.070Z | Extended Element | 5333549.0712170824,2184676.0308586597,360.99534843365376 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.078Z | Extended Element | 5333549.3759808382,2184676.0354046687,360.99668954335419 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.088Z | Extended Element | 5333549.6807445949,2184676.0399506753,360.99803065305463 | -179.145 | -4.91676e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.099Z | Extended Element | 5333549.9855083516,2184676.0444966834,360.99937176275506 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.109Z | Extended Element | 5333550.2902721055,2184676.0490426915,361.00071287245544 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.119Z | Extended Element | 5333550.5950358603,2184676.0535886986,361.00205398215599 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.128Z | Extended Element | 5333550.8997996161,2184676.0581347067,361.00339509185631 | -179.145 | 1.3752e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.136Z | Extended Element | 5333551.2045633728,2184676.0626807143,361.00473620155685 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.144Z | Extended Element | 5333551.5093271295,2184676.0672267219,361.00607731125717 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.153Z | Extended Element | 5333551.8140908824,2184676.07177273,361.00741842095766 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.162Z | Extended Element | 5333552.1188546391,2184676.0763187376,361.0087595306581 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.173Z | Extended Element | 5333552.4236183958,2184676.0808647452,361.01010064035853 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.183Z | Extended Element | 5333552.7283821516,2184676.0854107533,361.01144175005902 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
