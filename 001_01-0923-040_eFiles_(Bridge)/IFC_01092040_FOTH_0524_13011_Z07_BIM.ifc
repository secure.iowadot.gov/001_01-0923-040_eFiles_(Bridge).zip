Properties of the parts of a building model (IFC4X3_ADD2), part 26 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.570Z | Complex Chain | 5333550.5345299821,2184689.5484456629,360.59514196580079 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.582Z | Line | 5333550.8332404532,2184689.4262576951,358.67173548098515 | 0 | 0 | 0 | 0,-0.2998927840963006,0 | 0.86382386833429337,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.590Z | Line | 5333550.9435584126,2184689.7440222143,358.67173548191886 | 0 | 0 | 0 | 0,0,0 | 0.97297591622918844,0.014513392467051744,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.598Z | Line | 5333550.8979368415,2184689.3802708192,358.76698567181131 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.606Z | Line | 5333551.0168830249,2184689.722888445,358.76698567192238 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.617Z | Line | 5333551.8649518304,2184690.2520985296,358.74793563323658 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.626Z | Line | 5333551.8683613697,2184690.0235234997,358.74793563259925 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.635Z | Line | 5333551.848393077,2184689.7945997557,358.74793563250392 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.646Z | Line | 5333547.1929469295,2184676.1854256042,358.74793563351136 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.656Z | Line | 5333547.1963564688,2184675.9568505744,358.74793563377261 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.666Z | Line | 5333551.0513139423,2184690.197094548,358.74793563323658 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.678Z | Line | 5333551.0531134205,2184690.0764577268,358.74793563323658 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.686Z | Line | 5333551.0549128996,2184689.9558209055,358.74793563323664 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.697Z | Line | 5333546.3782992717,2184675.9875153811,358.7479356337725 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.705Z | Line | 5333546.3764997926,2184676.1081522019,358.7479356337725 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.716Z | Line | 5333546.3747003144,2184676.2287890231,358.7479356337725 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.725Z | Line | 5333546.3395573022,2184676.4824625142,358.67173548086805 | 0 | 0 | 0 | 0,-0.2998927840963006,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.735Z | Line | 5333546.4042536896,2184676.4364756392,358.74793563421196 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.745Z | Complex Chain | 5333554.67689755,2184689.821938083,360.87729244929432 | 0 | 0 | 0 | -3.6445018583908677,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.754Z | Complex Chain | 5333554.5570168514,2184689.4766255436,360.8831325943703 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.765Z | Complex Chain | 5333554.4320612745,2184689.1166982101,360.88971971006794 | 0 | 0 | 0 | -3.6445018583908677,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.773Z | Complex Chain | 5333554.3121315427,2184688.7712475327,360.89604187128037 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.784Z | Complex Chain | 5333554.19220181,2184688.4257968543,360.90236404036023 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.796Z | Complex Chain | 5333554.0722720772,2184688.0803461769,360.90868620938346 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.804Z | Complex Chain | 5333553.9523423454,2184687.7348954971,360.91500837810872 | 0 | 0 | 0 | -3.6445018583908677,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.815Z | Complex Chain | 5333553.8273867667,2184687.3749681665,360.92157404054365 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.824Z | Complex Chain | 5333553.7024311898,2184687.0150408335,360.9281825970686 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.834Z | Complex Chain | 5333553.5774756148,2184686.6551135005,360.93476970640876 | 0 | 0 | 0 | -3.6445018585946096,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.846Z | Complex Chain | 5333553.457545883,2184686.3096628208,360.94109187555568 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.855Z | Complex Chain | 5333553.3376161503,2184685.9642121447,360.94741404430499 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.866Z | Complex Chain | 5333553.2176864156,2184685.6187614631,360.95373621299615 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.878Z | Complex Chain | 5333553.0977566848,2184685.2733107843,360.96005838229797 | 0 | 0 | 0 | -3.6445018585946096,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.886Z | Complex Chain | 5333552.9728011088,2184684.9133834522,360.96662404550671 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.897Z | Complex Chain | 5333552.8478455283,2184684.5534561225,360.97323260042197 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.906Z | Complex Chain | 5333552.7228899561,2184684.1935287891,360.97981971025791 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.913Z | Complex Chain | 5333552.6029602233,2184683.8480781098,360.98583722514667 | 0 | 0 | 0 | -3.6445018583908677,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.922Z | Complex Chain | 5333552.4830304906,2184683.50262743,360.98959218883726 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.931Z | Complex Chain | 5333552.3631007578,2184683.157176754,360.99075345794307 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.940Z | Complex Chain | 5333552.2431710241,2184682.8117260723,360.98912544422143 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.951Z | Complex Chain | 5333552.1182154436,2184682.4517987412,360.98446236337617 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.959Z | Complex Chain | 5333551.9932598658,2184682.0918714087,360.97735628167146 | 0 | 0 | 0 | -3.6445018583908677,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.967Z | Complex Chain | 5333551.8683042955,2184681.7319440767,360.96962244596352 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.976Z | Complex Chain | 5333551.7483745627,2184681.3864933974,360.96219967300766 | 0 | 0 | 0 | -3.6445018585946096,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.985Z | Complex Chain | 5333551.6284448309,2184681.0410427195,360.95477690040468 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.993Z | Complex Chain | 5333551.5085150991,2184680.6955920439,360.94735412767392 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.003Z | Complex Chain | 5333551.3885853663,2184680.3501413651,360.93993135539012 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.013Z | Complex Chain | 5333551.2636297848,2184679.9902140349,360.93223574344427 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.021Z | Complex Chain | 5333551.1386742052,2184679.6302867001,360.92446368371748 | 0 | 0 | 0 | -3.6445018585946096,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.032Z | Complex Chain | 5333551.0137186358,2184679.2703593676,360.91672984801636 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.040Z | Complex Chain | 5333550.893788903,2184678.9249086864,360.90930707532613 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.051Z | Complex Chain | 5333550.7738591703,2184678.5794580076,360.90188430243927 | 0 | 0 | 0 | -3.6445018583908677,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.062Z | Complex Chain | 5333550.6539294375,2184678.2340073269,360.89446152987335 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.072Z | Complex Chain | 5333550.5339997029,2184677.8885566434,360.88692731870418 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.083Z | Complex Chain | 5333550.4090441205,2184677.5286293165,360.87934314508402 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.091Z | Complex Chain | 5333550.2840885511,2184677.1687019831,360.87157108518562 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.101Z | Complex Chain | 5333550.1591329761,2184676.8087746501,360.86377035646166 | 0 | 0 | 0 | -3.6445018593221903,-0.054363202769309282,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.112Z | Complex Chain | 5333546.2558743423,2184677.2240254735,360.29477019538911 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.1306824553757906,0 | 1.1023754291236401,4.6566128730773926e-10,0.3035503395274759
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.121Z | Complex Chain | 5333547.110460002,2184679.6856101896,360.34374149587956 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.1306824553757906,0 | 1.1023754291236401,6.7750227823737408e-10,0.3035503395274759
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.132Z | Complex Chain | 5333547.9650456607,2184682.1471948978,360.3927127930512 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.1306824553757906,0 | 1.1023754291236401,6.7750227823737408e-10,0.3035503395274759
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.143Z | Complex Chain | 5333548.8196312943,2184684.608779538,360.38426589394828 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.1306824553757906,0 | 1.1023754291236401,4.6566128730773926e-10,0.3035503395274759
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.154Z | Complex Chain | 5333549.674216968,2184687.0703643267,360.34141603348826 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.1306824553757906,0 | 1.1023754281923175,4.6566128730773926e-10,0.3035503395274759
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.164Z | Complex Chain | 5333550.5288028298,2184689.5319489674,360.29856606435334 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.1306824553757906,0 | 1.1023754291236401,6.7750227823737408e-10,0.3035503395274759
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.173Z | Line | 5333548.4493582947,2184680.0038760877,358.85271084353968 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,0 | 9.3132257461547852e-10,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.183Z | Line | 5333546.749964118,2184677.4322745898,358.74793563365779 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.194Z | Line | 5333546.435356576,2184676.758406803,358.6717354812638 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386926561594,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.203Z | Complex Chain | 5333550.0633337004,2184676.5328303627,360.85828066162281 | 0 | 0 | 0 | -3.6445018593221903,-0.05436320323497057,-0.99382283266243121 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.214Z | Complex Chain | 5333546.0351194907,2184676.5881538545,360.28212002997481 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.223Z | Complex Chain | 5333546.0408466188,2184676.6046505263,360.57869595887342 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.235Z | Line | 5333548.4591354392,2184682.3554440155,358.85588584931907 | 0 | 0 | 0 | 0,0,0 | 9.3132257461547852e-10,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.246Z | Line | 5333549.313721098,2184684.8170287288,358.81143576068945 | 0 | 0 | 0 | -9.3132257461547852e-10,0,0 | 0,4.6566128730773926e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.256Z | Line | 5333550.1683067586,2184687.2786134393,358.76698567209718 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.269Z | Extended Element | 5333550.9742289754,2184689.8323670016,359.88702595695565 | -109.145 | 0.942122 | 90 | 5.5369402292282377e-10,-0.11961207632969273,-2.2934548601107392 | 7.2881125718485267,0.87922976531842778,2.6744548598779088
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.299Z | Extended Element | 5333550.6063792249,2184689.7554039229,360.59153943650313 | -89.1454 | -8.52089e-08 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.327Z | Extended Element | 5333551.7355906097,2184689.7558365604,360.59182660127317 | -89.1454 | -1.18836e-07 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.352Z | Extended Element | 5333550.5345299821,2184689.5484456639,360.59514196580085 | -109.145 | -2.63946e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.379Z | Extended Element | 5333551.6311782589,2184689.52589241,360.60211640387774 | 70.8546 | -88.9233 | -28.8908 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.402Z | Extended Element | 5333551.4761305749,2184688.7997582168,360.6016946273499 | 70.8546 | -180 | 3.5517e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.430Z | Extended Element | 5333550.409574192,2184689.1885183756,360.60140746252222 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.456Z | Extended Element | 5333550.2896444704,2184688.8430677205,360.60742087355817 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.483Z | Extended Element | 5333551.3562008534,2184688.4543075613,360.60770803838585 | 70.8546 | 180 | 2.76191e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.512Z | Extended Element | 5333550.1697147386,2184688.4976170431,360.61343428480279 | -109.145 | -3.49559e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.540Z | Extended Element | 5333551.2362711187,2184688.1088568824,360.61372144963042 | 70.8546 | -180 | -9.96052e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.572Z | Extended Element | 5333550.049785004,2184688.1521663647,360.61944769616053 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.600Z | Extended Element | 5333551.1163413851,2184687.763406205,360.61973486098822 | 70.8546 | -180 | 3.5517e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.627Z | Extended Element | 5333549.9298552731,2184687.8067156854,360.62546110797467 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.653Z | Extended Element | 5333550.9964116523,2184687.4179555257,360.62574827280235 | 70.8546 | -180 | -9.96345e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.679Z | Extended Element | 5333549.8048996972,2184687.4467883534,360.63172652098626 | -109.145 | -2.90115e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.704Z | Extended Element | 5333550.8714560764,2184687.0580281927,360.63201368581394 | 70.8546 | 180 | 2.76221e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.730Z | Extended Element | 5333549.6799441185,2184687.0868610209,360.63799193403781 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.755Z | Extended Element | 5333550.7765923953,2184687.0643077679,360.64496637301153 | 70.8546 | -88.9233 | -28.8908 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.783Z | Extended Element | 5333549.5549885007,2184686.7269336767,360.64425737418776 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.805Z | Extended Element | 5333550.6215448845,2184686.3381735175,360.64454453901544 | 70.8546 | -180 | 3.55141e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.832Z | Extended Element | 5333549.4350587772,2184686.3814829141,360.65027076109789 | -109.145 | -2.3067e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.858Z | Extended Element | 5333550.5016151583,2184685.9927227539,360.65055792592551 | 70.8546 | 180 | -1.78555e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.885Z | Extended Element | 5333549.3151290426,2184686.0360322352,360.6562841737358 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.911Z | Extended Element | 5333550.3816854265,2184685.6472720751,360.65657133856342 | 70.8546 | -180 | 3.55141e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.938Z | Extended Element | 5333549.1951993117,2184685.6905815569,360.66229758465425 | -109.145 | -3.49559e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.964Z | Extended Element | 5333550.2617556918,2184685.3018213967,360.66258474948188 | 70.8546 | 180 | -9.96051e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:16.989Z | Extended Element | 5333549.0752695771,2184685.3451308776,360.66831099598977 | -109.145 | -2.90115e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.016Z | Extended Element | 5333550.1418259619,2184684.9563707178,360.66859816081745 | 70.8546 | 180 | 2.76191e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.045Z | Extended Element | 5333548.9503140021,2184684.985203546,360.67457640923237 | -109.145 | -1.18889e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.071Z | Extended Element | 5333550.0168703822,2184684.5964433863,360.67486357406 | 70.8546 | -180 | 4.3409e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.098Z | Extended Element | 5333548.8253584253,2184684.6252762126,360.68084182221071 | -109.145 | -2.63946e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.132Z | Extended Element | 5333549.9220067244,2184684.6027229796,360.68781623347104 | 70.8546 | -88.9233 | -28.8908 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.157Z | Extended Element | 5333548.7004028494,2184684.2653488801,360.687107234623 | -109.145 | -1.18889e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.186Z | Extended Element | 5333549.7669592286,2184683.8765887204,360.68739439945062 | 70.8546 | -180 | -9.96051e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.212Z | Extended Element | 5333548.5804731175,2184683.9198982012,360.69312064695333 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.238Z | Extended Element | 5333549.6470294995,2184683.531138042,360.69340781178101 | 70.8546 | -180 | 3.55141e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.267Z | Extended Element | 5333548.4605433829,2184683.574447521,360.69913405816806 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.294Z | Extended Element | 5333549.527099763,2184683.1856873613,360.69942122299574 | 70.8546 | -180 | -9.96345e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.319Z | Extended Element | 5333548.340613652,2184683.2289968436,360.70514746961243 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.340Z | Extended Element | 5333549.407170034,2184682.8402366829,360.70543463444011 | 70.8546 | -180 | 2.76191e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.352Z | Extended Element | 5333548.6385650346,2184683.1046217112,360.00464364738048 | -109.145 | -1.07668 | 90 | -1.7580601532669464e-10,-0.13408858966963655,-2.2934548617405555 | 7.2901914373000549,0.89855978607986764,2.6744548582480943
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.385Z | Extended Element | 5333548.2206839453,2184682.8835462364,360.70360966442632 | -109.145 | -2.3067e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.413Z | Extended Element | 5333549.2872403264,2184682.4947860772,360.70389682925389 | 70.8546 | 180 | 2.76191e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.440Z | Extended Element | 5333548.0957283657,2184682.5236189049,360.69644919328977 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.467Z | Extended Element | 5333549.1622847486,2184682.1348587442,360.69673635811745 | 70.8546 | -180 | -9.96052e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.494Z | Extended Element | 5333547.9707727917,2184682.1636915733,360.68928872084228 | -109.145 | -1.18889e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.520Z | Extended Element | 5333549.0674210917,2184682.1411383399,360.6962631325722 | 70.8546 | -88.9233 | -28.8908 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.546Z | Extended Element | 5333547.8458172148,2184681.8037642413,360.68212824955856 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.571Z | Extended Element | 5333548.912373594,2184681.4150040811,360.68241541438618 | 70.8546 | -180 | 2.76221e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.598Z | Extended Element | 5333547.725887483,2184681.4583135624,360.67525577900238 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.625Z | Extended Element | 5333548.7924438631,2184681.0695534023,360.67554294383007 | 70.8546 | -180 | 3.5517e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.651Z | Extended Element | 5333547.6059577484,2184681.1128628845,360.66838330852903 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.678Z | Extended Element | 5333548.6725141304,2184680.7241027243,360.66867047335666 | 70.8546 | -180 | -1.78555e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.705Z | Extended Element | 5333547.4860280184,2184680.7674122071,360.6615108380098 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.733Z | Extended Element | 5333548.5525843995,2184680.3786520469,360.66179800283749 | 70.8546 | -180 | -1.78555e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.758Z | Extended Element | 5333547.3660982847,2184680.4219615282,360.65463836708881 | -109.145 | -1.78333e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.786Z | Extended Element | 5333548.4326546649,2184680.0332013676,360.65492553191655 | 70.8546 | -180 | -9.96345e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.814Z | Extended Element | 5333547.2411427088,2184680.0620341976,360.64747789512245 | -109.145 | -1.18889e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.839Z | Extended Element | 5333548.3076990927,2184679.6732740374,360.64776505995019 | 70.8546 | -180 | 4.3409e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.866Z | Extended Element | 5333547.116187132,2184679.7021068651,360.64031742358668 | -109.145 | -1.18889e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.894Z | Extended Element | 5333548.212835432,2184679.6795536308,360.64729183542732 | 70.8546 | -88.9233 | -28.8908 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.920Z | Extended Element | 5333546.991231557,2184679.3421795312,360.63315695042604 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.947Z | Extended Element | 5333548.0577879371,2184678.9534193706,360.63344411525361 | 70.8546 | -180 | -1.78555e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.970Z | Extended Element | 5333546.8713018233,2184678.9967288519,360.62628448098673 | -109.145 | -3.49559e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:17.996Z | Extended Element | 5333547.9378582053,2184678.6079686917,360.62657164581441 | 70.8546 | -180 | 2.76221e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.022Z | Extended Element | 5333546.7513720905,2184678.6512781726,360.61941201026542 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.050Z | Extended Element | 5333547.8179284707,2184678.2625180134,360.61969917509316 | 70.8546 | -180 | 3.55141e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.077Z | Extended Element | 5333546.6314423559,2184678.3058274915,360.61253954016667 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.102Z | Extended Element | 5333547.6979987379,2184677.9170673313,360.61282670499423 | 70.8546 | -180 | -1.78555e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.125Z | Extended Element | 5333546.511512625,2184677.9603768121,360.60566706967876 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.149Z | Extended Element | 5333547.5780690061,2184677.5716166515,360.60595423450644 | 70.8546 | -180 | -1.78525e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.174Z | Extended Element | 5333546.3865570482,2184677.6004494773,360.59850659606769 | -109.145 | -1.45057e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.202Z | Extended Element | 5333547.4531134302,2184677.2116893181,360.59879376089543 | 70.8546 | -180 | 3.55141e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.230Z | Extended Element | 5333546.2616014723,2184677.2405221472,360.59134612436492 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.256Z | Extended Element | 5333547.3582497714,2184677.2179689147,360.59832053491476 | 70.8546 | -88.9233 | -28.8908 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.287Z | Extended Element | 5333546.1366458945,2184676.8805948142,360.58418565371227 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.316Z | Extended Element | 5333547.2032022756,2184676.491834654,360.58447281854001 | 70.8546 | -180 | -1.78525e-08 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.342Z | Extended Element | 5333546.0408466188,2184676.6046505263,360.57869595887354 | -109.145 | -2.04502e-07 | -90 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.369Z | Extended Element | 5333547.1074029999,2184676.2158903666,360.57898312370111 | 70.8546 | -180 | -9.96345e-09 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.382Z | Extended Element | 5333550.9742289772,2184689.8323670076,358.67173548116017 | -89.1454 | 90 | 0 | -5.6177285046032921e-14,-1.1479490691357341e-09,2.2127355503442914e-10 | 1.0667999999999438,0.9730841540040287,0.48260000022128224
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.409Z | Extended Element | 5333551.0513139442,2184690.197094548,358.74793563323658 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.435Z | Extended Element | 5333551.8649518313,2184690.2520985301,358.74793563323658 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.459Z | Extended Element | 5333551.0531134214,2184690.0764577277,358.74793563323658 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.482Z | Extended Element | 5333551.0549128996,2184689.955820906,358.74793563323664 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.505Z | Extended Element | 5333551.8683613697,2184690.0235234997,358.74793563259931 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.518Z | Extended Element | 5333551.9472048944,2184689.8468804001,358.67173548116017 | -109.145 | 0 | 90 | 6.9239103339668873e-10,-5.6177285046032921e-14,-2.2934548610333101 | 7.4687791259493679,1.0667999999999438,3.2078548589553373
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.543Z | Extended Element | 5333551.0168830249,2184689.7228884446,358.76698567192244 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.571Z | Extended Element | 5333551.848393078,2184689.7945997552,358.74793563250392 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.598Z | Extended Element | 5333550.8979368424,2184689.3802708187,358.76698567181137 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.623Z | Extended Element | 5333550.7729812702,2184689.0203434867,358.76698567154773 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.646Z | Extended Element | 5333550.6530515375,2184688.6748928092,358.76698567154682 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.673Z | Extended Element | 5333551.4928342057,2184688.7704329332,358.76698567178198 | -67.7254 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.698Z | Extended Element | 5333550.5331218047,2184688.3294421295,358.76698567146991 | -67.7254 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.724Z | Extended Element | 5333551.3729044739,2184688.4249822558,358.76698567150595 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.752Z | Extended Element | 5333550.4131920747,2184687.983991453,358.7669856716376 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.781Z | Extended Element | 5333551.2529747393,2184688.0795315756,358.76698567190391 | -67.7254 | -9.70736e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.808Z | Extended Element | 5333550.2932623401,2184687.6385407737,358.76698567097912 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.837Z | Extended Element | 5333551.1330450093,2184687.7340808986,358.76698567158724 | -67.7254 | -3.34062e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.866Z | Extended Element | 5333550.1683067586,2184687.2786134393,358.76698567209723 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.892Z | Extended Element | 5333551.0131152766,2184687.3886302202,358.76698567110236 | -67.7254 | -1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.916Z | Extended Element | 5333550.0433511818,2184686.9186861101,358.81143576109679 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.942Z | Extended Element | 5333549.9183956068,2184686.5587587757,358.81143576130728 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.970Z | Extended Element | 5333549.7984658731,2184686.2133080973,358.81143576122531 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:18.993Z | Extended Element | 5333550.6382485479,2184686.3088482209,358.81143576102414 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.020Z | Extended Element | 5333549.6785361413,2184685.8678574199,358.81143576132604 | -67.7254 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.046Z | Extended Element | 5333550.5183188152,2184685.9633975415,358.81143576030644 | -67.7254 | -2.14209e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.073Z | Extended Element | 5333550.3983890824,2184685.6179468646,358.81143576095866 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.100Z | Extended Element | 5333549.5586064067,2184685.5224067392,358.81143576217602 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.129Z | Extended Element | 5333549.4386766776,2184685.1769560603,358.81143576107752 | -67.7254 | 1.18495e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.153Z | Extended Element | 5333550.2784593469,2184685.2724961843,358.8114357613419 | -67.7254 | 9.70734e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.179Z | Extended Element | 5333549.3137210989,2184684.8170287288,358.81143576068951 | -67.7254 | 3.34062e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.205Z | Extended Element | 5333550.1585296169,2184684.9270455083,358.81143576099896 | -67.7254 | -2.15568e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.234Z | Extended Element | 5333549.1887655174,2184684.4571013981,358.85588584913125 | -67.7254 | -2.1421e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.259Z | Extended Element | 5333549.0638099471,2184684.0971740661,358.85588584973192 | -67.7254 | -2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.286Z | Extended Element | 5333548.9438802162,2184683.7517233863,358.85588584994531 | -67.7254 | 7.56523e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.314Z | Extended Element | 5333549.7836628864,2184683.8472635122,358.85588584954246 | -67.7254 | -2.14211e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.341Z | Extended Element | 5333548.8239504835,2184683.406272708,358.85588584973613 | -67.7254 | 7.56524e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.366Z | Extended Element | 5333549.6637331545,2184683.5018128329,358.85588584923067 | -67.7254 | 7.56523e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.393Z | Extended Element | 5333549.5438034208,2184683.1563621536,358.85588584926012 | -67.7254 | 1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.408Z | Extended Element | 5333546.2935108412,2184676.3498283373,358.67173548116017 | 70.8546 | 0 | 90 | 4.595550606723009e-10,-5.6177285046032921e-14,-2.2934548599855757 | 7.4687791257165372,1.0667999999999438,3.207854860003081
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.437Z | Extended Element | 5333548.7040207526,2184683.060822031,358.85588584963938 | -67.7254 | -2.1421e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.464Z | Extended Element | 5333549.42387369,2184682.8109114761,358.85588584922004 | -67.7254 | 9.70733e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.492Z | Extended Element | 5333548.5840910189,2184682.7153713494,358.85588584955229 | -67.7254 | -2.14211e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.522Z | Extended Element | 5333549.3039439553,2184682.4654607945,358.8558858493347 | -67.7254 | 9.70733e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.548Z | Extended Element | 5333548.4591354392,2184682.3554440159,358.85588584931912 | -67.7254 | -9.70734e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.574Z | Extended Element | 5333548.3341798605,2184681.9955166848,358.85271084298552 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.602Z | Extended Element | 5333548.2092242893,2184681.6355893528,358.85271084341133 | -67.7254 | -2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.632Z | Extended Element | 5333548.9290772257,2184681.3856787989,358.85271084339433 | -67.7254 | -1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.659Z | Extended Element | 5333548.0892945584,2184681.2901386749,358.85271084340718 | -67.7254 | -1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.689Z | Extended Element | 5333548.8091474948,2184681.0402281214,358.85271084347471 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.724Z | Extended Element | 5333547.9693648256,2184680.9446879961,358.85271084340303 | -67.7254 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.750Z | Extended Element | 5333548.6892177593,2184680.6947774426,358.85271084392116 | -67.7254 | -1.18495e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.776Z | Extended Element | 5333547.8494350919,2184680.5992373205,358.85271084353042 | -67.7254 | -1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.807Z | Extended Element | 5333548.5692880275,2184680.349326767,358.85271084364058 | -67.7255 | -3.34062e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.835Z | Extended Element | 5333547.7295053611,2184680.2537866421,358.85271084347346 | -67.7255 | -2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.864Z | Extended Element | 5333548.4493582938,2184680.0038760873,358.85271084353974 | -67.7255 | -2.15568e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.892Z | Extended Element | 5333547.6045497805,2184679.8938593115,358.85223347731647 | -67.7255 | -1.18494e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.919Z | Extended Element | 5333547.479594199,2184679.5339319766,358.80032323851128 | -67.7255 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.947Z | Extended Element | 5333547.3546386305,2184679.1740046451,358.80032323881943 | -67.7255 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:19.975Z | Extended Element | 5333548.074491566,2184678.9240940898,358.80032323850571 | -67.7255 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.004Z | Extended Element | 5333547.2347088968,2184678.8285539644,358.80032323882944 | -67.7255 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.033Z | Extended Element | 5333547.9545618324,2184678.57864341,358.80032323904021 | -67.7255 | -2.15568e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.059Z | Extended Element | 5333547.1147791632,2184678.4831032846,358.8003232388395 | -67.7255 | 3.55483e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
