Properties of the parts of a building model (IFC4X3_ADD2), part 4 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:10.511Z | Smart Solid | 5333553.8411430018,2184677.0466751331,360.7769977139954 | 0 | 0 | 0 | -7.0668673248144858,-0.53706607944507156,-0.046667690974175002 | 7.0680775386549257,0.53828032687251959,0.047872435057301641 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 274.943 us survey square foot; Volume: 16.5247 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-R; Type: Haunch; Type Text: Haunch; Span Name: Abut1 - Pier1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:10.724Z | Smart Solid | 5333580.819227838,2184689.6932943864,360.33398526797055 | 0 | 0 | 0 | -15.447988688911499,-0.66209734040820678,-0.46746402068455417 | 15.44798235522201,0.66207586237539506,0.46746864500587726 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 1414.63 us survey square foot; Volume: 444.206 ft³ (us survey); Beam Segment Properties - Length: 101.333 us survey foot; Beam Name: Beam-L; Type: Custom; Type Text: Custom; Span Name: Pier1 - Pier2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:10.857Z | Smart Solid | 5333580.8191821184,2184689.6932943864,360.82402844805688 | 0 | 0 | 0 | -15.447942964917488,-0.662097341389563,-0.043105574018056814 | 15.44796371068308,0.66207490369347854,0.043104959779293767 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 615.167 us survey square foot; Volume: 56.6349 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-L; Type: Haunch; Type Text: Haunch; Span Name: Pier1 - Pier2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:11.060Z | Smart Solid | 5333579.9646431291,2184687.2316941833,360.38228092456183 | 0 | 0 | 0 | -15.447989637956605,-0.66208185077899062,-0.46940873316764498 | 15.447993596507498,0.6620915368870941,0.4694126264850344 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 1414.63 us survey square foot; Volume: 444.206 ft³ (us survey); Beam Segment Properties - Length: 101.333 us survey foot; Beam Name: Beam-2; Type: Custom; Type Text: Custom; Span Name: Pier1 - Pier2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:11.190Z | Smart Solid | 5333579.9646126488,2184687.2316941833,360.871684023368 | 0 | 0 | 0 | -15.447959154361266,-0.66208184976713735,-0.044410289020281754 | 15.447947521038042,0.66209039508171386,0.044394589422713987 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 615.167 us survey square foot; Volume: 56.6349 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-2; Type: Haunch; Type Text: Haunch; Span Name: Pier1 - Pier2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:11.396Z | Smart Solid | 5333579.1100584203,2184684.7701244601,360.43046990093978 | 0 | 0 | 0 | -15.447990588537225,-0.66209683889785576,-0.47135895856622312 | 15.448004834380374,0.66207672890358915,0.47135108055799507 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 1414.63 us survey square foot; Volume: 444.206 ft³ (us survey); Beam Segment Properties - Length: 101.333 us survey foot; Beam Name: Beam-3; Type: Custom; Type Text: Custom; Span Name: Pier1 - Pier2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:11.534Z | Smart Solid | 5333579.1100126998,2184684.7701244601,360.91921767843536 | 0 | 0 | 0 | -15.447944868500478,-0.66209683823574339,-0.045705291366516576 | 15.447961808303972,0.66207540544215604,0.045699860678214702 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 615.131 us survey square foot; Volume: 56.6103 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-3; Type: Haunch; Type Text: Haunch; Span Name: Pier1 - Pier2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:11.746Z | Smart Solid | 5333578.2555346712,2184682.308524257,360.42960121920242 | 0 | 0 | 0 | -15.448052500627931,-0.66208134956713971,-0.4733074792891756 | 15.448029753171909,0.66209240234381439,0.47329122498630982 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 1414.63 us survey square foot; Volume: 444.206 ft³ (us survey); Beam Segment Properties - Length: 101.333 us survey foot; Beam Name: Beam-4; Type: Custom; Type Text: Custom; Span Name: Pier1 - Pier2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:11.883Z | Smart Solid | 5333578.2554432303,2184682.308524257,360.91781559563117 | 0 | 0 | 0 | -15.447961057927841,-0.6620813480130211,-0.047120523797559599 | 15.447945621822289,0.66209089730421078,0.047100043926474572 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 615.131 us survey square foot; Volume: 56.6103 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-4; Type: Haunch; Type Text: Haunch; Span Name: Pier1 - Pier2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:12.094Z | Smart Solid | 5333577.400995682,2184679.8469545338,360.37967487934975 | 0 | 0 | 0 | -15.448099171205705,-0.6620963370180265,-0.47525429463636548 | 15.448095800457555,0.66207759564895707,0.47523305974217356 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 1414.63 us survey square foot; Volume: 444.206 ft³ (us survey); Beam Segment Properties - Length: 101.333 us survey foot; Beam Name: Beam-5; Type: Custom; Type Text: Custom; Span Name: Pier1 - Pier2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:12.227Z | Smart Solid | 5333577.4008432813,2184679.8469545338,360.86744729489459 | 0 | 0 | 0 | -15.44794676868405,-0.6620963364897855,-0.048625505529059865 | 15.447959910290322,0.66207590929582727,0.048625619246071644 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 615.167 us survey square foot; Volume: 56.6349 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-5; Type: Haunch; Type Text: Haunch; Span Name: Pier1 - Pier2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:12.434Z | Smart Solid | 5333576.5464719329,2184677.3853543308,360.32962661925325 | 0 | 0 | 0 | -15.448161079849568,-0.66208084536388978,-0.47719138457883215 | 15.448146608462821,0.66209326848856476,0.47718460707009586 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 1414.63 us survey square foot; Volume: 444.206 ft³ (us survey); Beam Segment Properties - Length: 101.333 us survey foot; Beam Name: Beam-R; Type: Custom; Type Text: Custom; Span Name: Pier1 - Pier2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:12.572Z | Smart Solid | 5333576.5462738127,2184677.3853543308,360.81697231394463 | 0 | 0 | 0 | -15.447962958987747,-0.66208084510426979,-0.050136016410484346 | 15.447943719306011,0.66209139857362964,0.05015159610047544 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 615.167 us survey square foot; Volume: 56.6349 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-R; Type: Haunch; Type Text: Haunch; Span Name: Pier1 - Pier2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:12.769Z | Smart Solid | 5333603.5242672088,2184690.0319735841,360.33755143510285 | 0 | 0 | 0 | -7.0669059726845855,-0.53708048288125954,-0.46316623669253487 | 7.0669137969723863,0.53706013521799312,0.46318307890594962 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.581 us survey square foot; Volume: 203.107 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-L; Type: Custom; Type Text: Custom; Span Name: Pier2 - Abut2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:12.995Z | Smart Solid | 5333603.5243129283,2184690.0319735841,360.82372364744725 | 0 | 0 | 0 | -7.0668697746228659,-0.53707926022199914,-0.034938606307722629 | 7.0680750877527281,0.53826714586333924,0.034955173731914549 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.336 us survey square foot; Volume: 17.0844 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-L; Type: Haunch; Type Text: Haunch; Span Name: Pier2 - Abut2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:13.197Z | Smart Solid | 5333602.6696977392,2184687.5703733806,360.38871221742443 | 0 | 0 | 0 | -7.0669099887202496,-0.53706480904642584,-0.46228651891327244 | 7.0668976101440695,0.53707562975185297,0.46228754632158164 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.581 us survey square foot; Volume: 203.107 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-2; Type: Custom; Type Text: Custom; Span Name: Pier2 - Abut2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:13.421Z | Smart Solid | 5333602.6697282195,2184687.5703733806,360.87488442976883 | 0 | 0 | 0 | -7.0668707240083721,-0.53706376813935119,-0.034058798508775801 | 7.0680741387769714,0.53828263770953955,0.034059613573802883 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.337 us survey square foot; Volume: 17.0849 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-2; Type: Haunch; Type Text: Haunch; Span Name: Pier2 - Abut2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:13.640Z | Smart Solid | 5333601.8151130304,2184685.1088036573,360.43975107950212 | 0 | 0 | 0 | -7.0668987460879897,-0.53707961551393546,-0.46139363587285664 | 7.0668966566589155,0.53706064045879831,0.46140169152959376 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.581 us survey square foot; Volume: 203.107 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-3; Type: Custom; Type Text: Custom; Span Name: Pier2 - Abut2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:13.866Z | Smart Solid | 5333601.8151435098,2184685.1088036573,360.92586233172466 | 0 | 0 | 0 | -7.0668716756827719,-0.53707875684214756,-0.033104879644722161 | 7.068073188973262,0.53826764900675084,0.033130119622028678 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.32 us survey square foot; Volume: 17.0735 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-3; Type: Haunch; Type Text: Haunch; Span Name: Pier2 - Abut2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:14.066Z | Smart Solid | 5333600.9605435608,2184682.6472034543,360.44174752349505 | 0 | 0 | 0 | -7.0669027462791281,-0.53706394138094471,-0.46051516033702211 | 7.0668804656604234,0.53707613363805118,0.46050229591827307 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.581 us survey square foot; Volume: 203.107 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-4; Type: Custom; Type Text: Custom; Span Name: Pier2 - Abut2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:14.300Z | Smart Solid | 5333600.960558801,2184682.6472034543,360.92785877571754 | 0 | 0 | 0 | -7.0668726250372238,-0.53706326545663186,-0.032226342940546493 | 7.0680722353842196,0.53828314179901326,0.032230722383119317 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.32 us survey square foot; Volume: 17.0735 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-4; Type: Haunch; Type Text: Haunch; Span Name: Pier2 - Abut2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:14.528Z | Smart Solid | 5333600.105958852,2184680.1856337311,360.39467106934211 | 0 | 0 | 0 | -7.066891504812979,-0.53707874797659416,-0.4596195561461901 | 7.0668795150592985,0.53706114319946874,0.45961982878959645 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.581 us survey square foot; Volume: 203.107 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-5; Type: Custom; Type Text: Custom; Span Name: Pier2 - Abut2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:14.749Z | Smart Solid | 5333600.1059740921,2184680.1856337311,360.88084328168657 | 0 | 0 | 0 | -7.0668735754143794,-0.53707825346229598,-0.031391652192291807 | 7.0680712849351881,0.53826815308939335,0.031391901879652344 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.336 us survey square foot; Volume: 17.0848 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-5; Type: Haunch; Type Text: Haunch; Span Name: Pier2 - Abut2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:14.949Z | Smart Solid | 5333599.2513741422,2184677.724033528,360.34748793497585 | 0 | 0 | 0 | -7.0668802627416074,-0.53706307779268891,-0.45872948994501006 | 7.0668785661190849,0.53707663364856251,0.45873183442697796 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.581 us survey square foot; Volume: 203.107 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-R; Type: Custom; Type Text: Custom; Span Name: Pier2 - Abut2; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.157Z | Smart Solid | 5333599.2513893824,2184677.724033528,360.8336601473203 | 0 | 0 | 0 | -7.0668745249682097,-0.53706276463927705,-0.030501553807613043 | 7.0680703351198506,0.53828364107824989,0.03050390752244745 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.336 us survey square foot; Volume: 17.0848 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-R; Type: Haunch; Type Text: Haunch; Span Name: Pier2 - Abut2
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.164Z | Line | 5333545.621608723,2184673.0204092194,0 | 0 | 0 | 0 | 0,0,0 | 6.9974982896819711,20.155890297610313,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.168Z | Line String | 5333549.5911449734,2184683.9678045185,0 | 0 | 0 | 0 | -0.086988549679517746,-0.00113651342689991,0 | 0,0.72382092615589499,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.173Z | Line String | 5333548.7365593109,2184681.5062198061,0 | 0 | 0 | 0 | -0.086988548748195171,-0.0011365124955773354,0 | 0,0.72382092662155628,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.179Z | Line String | 5333550.4457306331,2184686.42938923,5.6843418860808015e-14 | 0 | 0 | 0 | -0.086988549679517746,-0.0011365129612386227,0 | 0,0.72382092708721757,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.183Z | Line String | 5333547.881973654,2184679.0446350956,-5.6843418860808015e-14 | 0 | 0 | 0 | -0.086988548748195171,-0.0011365129612386227,0 | 0,0.72382092662155628,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.187Z | Line String | 5333551.3003162928,2184688.8909739424,0 | 0 | 0 | 0 | -0.086988549679517746,-0.0011365129612386227,0 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.192Z | Line String | 5333547.0273879943,2184676.5830503809,0 | 0 | 0 | 0 | -0.086988550610840321,-0.0011365129612386227,-5.6843418860808015e-14 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.197Z | Line String | 5333549.8046256881,2184683.6753017674,0 | 0 | 0 | 0 | -0.8638255950063467,0,0 | 0.34987561497837305,1.3076899144798517,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.201Z | Line String | 5333548.9500400312,2184681.2137170569,0 | 0 | 0 | 0 | -0.863825598731637,0,0 | 0.34987561218440533,1.3076899135485291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.206Z | Line String | 5333550.6592113487,2184686.1368864789,0 | 0 | 0 | 0 | -0.86382559593766928,0,0 | 0.34987561404705048,1.307689914945513,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.212Z | Line String | 5333548.0954543715,2184678.7521323459,0 | 0 | 0 | 0 | -0.86382559780031443,0,0 | 0.3498756131157279,1.3076899140141904,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.216Z | Line String | 5333551.5137970094,2184688.5984711922,0 | 0 | 0 | 0 | -0.86382559780031443,0,0 | 0.34987561497837305,1.3076899140141904,0
Bearing3 | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:11:15.224Z; User Label: Bearing3; Origin: 5333543.2719244603,2184668.996459933,0; Yaw: 70.8546; Pitch: 0; Roll: 0; Bounding Box Low: -0.0073486682958900928,-0.0024384052027371711,0; Bounding Box High: 0.0073486682958900928,0.0024384045508823362,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.230Z | Line | 5333604.7463496681,2184673.9023432583,0 | 0 | 0 | 0 | 0,0,0 | 6.9974982896819711,20.155890297610313,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.234Z | Line String | 5333607.8613002598,2184682.3881538459,0 | 0 | 0 | 0 | -0.086988549679517746,-0.0011365129612386227,-5.6843418860808015e-14 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.238Z | Line String | 5333608.7158859177,2184684.8497385564,0 | 0 | 0 | 0 | -0.086988547816872597,-0.0011365129612386227,-5.6843418860808015e-14 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.244Z | Line String | 5333607.0067145992,2184679.9265691345,0 | 0 | 0 | 0 | -0.086988549679517746,-0.0011365129612386227,0 | 0,0.72382092708721757,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.247Z | Line String | 5333609.5704715746,2184687.3113232679,-5.6843418860808015e-14 | 0 | 0 | 0 | -0.086988548748195171,-0.00113651342689991,0 | 0,0.72382092615589499,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.252Z | Line String | 5333606.1521289377,2184677.4649844193,0 | 0 | 0 | 0 | -0.086988548748195171,-0.00113651342689991,-5.6843418860808015e-14 | 0,0.72382092615589499,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.256Z | Line String | 5333610.425057237,2184689.7729079798,5.6843418860808015e-14 | 0 | 0 | 0 | -0.086988549679517746,-0.0011365129612386227,0 | 0,0.72382092708721757,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.262Z | Line String | 5333608.0747809755,2184682.0956510962,0 | 0 | 0 | 0 | -0.86382559686899185,0,0 | 0.34987561404705048,1.3076899135485291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.267Z | Line String | 5333608.9293666352,2184684.5572358072,0 | 0 | 0 | 0 | -0.86382559780031443,0,0 | 0.3498756131157279,1.3076899135485291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.271Z | Line String | 5333607.2201953158,2184679.6340663834,0 | 0 | 0 | 0 | -0.86382559780031443,0,0 | 0.3498756131157279,1.307689914945513,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.277Z | Line String | 5333609.7839522958,2184687.0188205182,0 | 0 | 0 | 0 | -0.86382559780031443,0,0 | 0.34987561218440533,1.3076899140141904,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.282Z | Line String | 5333606.3656096552,2184677.1724816696,0 | 0 | 0 | 0 | -0.86382559780031443,0,0 | 0.34987561497837305,1.3076899140141904,0
Bearing4 | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:11:15.290Z; User Label: Bearing4; Origin: 5333603.5302925296,2184669.4848338887,0; Yaw: 70.8546; Pitch: 0; Roll: 0; Bounding Box Low: -0.0073430938646197319,-0.0024384042714145964,0; Bounding Box High: 0.0073430920019745827,0.0024384054822049108,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.313Z | Smart Solid | 5333595.978394717,2184689.7487223772,359.86114808229615 | 0 | 0 | 0 | -0.6465648540097475,-1.132984628138952,-0.00042547146032931782 | 0.64658269286155701,1.1329813522636891,0.00041973643340043054 | Solid - Surface Area: 28.7516 us survey square foot; Volume: 0.0397934 ft³ (us survey); General - Bearing: Bearing1; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.00277299 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.00277299 us survey foot; Depth at D1W2: 0.00277299 us survey foot; Depth at D2W1: 0.00277299 us survey foot; Depth at D2W2: 0.00277299 us survey foot; Top Elevation: 1180.65 us survey foot; Pad or Plate Pay Unit: 0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.318Z | Line | 5333540.8424774399,2184659.2543971543,0 | 0 | 0 | 0 | -4.9982130639255047,-14.397064498160034,0 | 0,0,0
BU01 (Bridge) | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:11:15.328Z; User Label: BU01 (Bridge); Origin: 5333545.5659237979,2184657.6145634716,0; Yaw: -109.145; Pitch: 0; Roll: 0; Bounding Box Low: -0.01133802579715848,-0.0024384052027371711,0; Bounding Box High: 0.011338024865835905,0.0024384045508823362,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.332Z | Line | 5333599.9672183851,2184660.1363311936,0 | 0 | 0 | 0 | -4.9982130629941821,-14.397064498625696,0 | 0,0,0
BU01 (Bridge) | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:11:15.340Z; User Label: BU01 (Bridge); Origin: 5333595.2437720271,2184661.7761648749,0; Yaw: -109.145; Pitch: 0; Roll: 0; Bounding Box Low: -0.011338025331497192,-0.0024384033400920218,0; Bounding Box High: 0.011338024400174618,0.0024384064135274854,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.346Z | Line | 5333559.8568335939,2184673.1545542539,0 | 0 | 0 | 0 | 0,0,0 | 6.9974982896819711,20.155890298075974,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.351Z | Line | 5333559.4249207955,2184673.3045009458,0 | 0 | 0 | 0 | 0,0,0 | 6.9974982887506485,20.155890297610313,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.364Z | Line String | 5333563.4433606546,2184684.1744310558,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.1368683772161603e-13 | 0,0.72382092708721757,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.368Z | Line String | 5333563.9298495846,2184684.1816877658,0 | 0 | 0 | 0 | -0.23937190230935812,-0.0034095384180545807,0 | 0,0.72382092662155628,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.372Z | Line String | 5333562.5887749949,2184681.7128463434,0 | 0 | 0 | 0 | -0.23937190324068069,-0.0034095393493771553,0 | 0,0.72382092615589499,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.377Z | Line String | 5333563.0752639258,2184681.7201030534,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.381Z | Line String | 5333564.2979463134,2184686.6360157668,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,0 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.385Z | Line String | 5333564.7844352461,2184686.6432724772,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-5.6843418860808015e-14 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.389Z | Line String | 5333562.2206782652,2184679.2585183401,5.6843418860808015e-14 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.1368683772161603e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.395Z | Line String | 5333561.7341893353,2184679.2512616306,0 | 0 | 0 | 0 | -0.23937190137803555,-0.003409538883715868,0 | 0,0.72382092662155628,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.400Z | Line String | 5333565.1525319749,2184689.0976004787,0 | 0 | 0 | 0 | -0.23937190230935812,-0.0034095384180545807,-1.1368683772161603e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.404Z | Line String | 5333565.6390209049,2184689.1048571891,0 | 0 | 0 | 0 | -0.23937190137803555,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.409Z | Line String | 5333561.3660926055,2184676.7969336296,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.414Z | Line String | 5333560.8796036756,2184676.7896769196,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,0 | 0,0.72382092662155628,2.2737367544323206e-13
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.419Z | Line String | 5333563.1123382729,2184683.228871047,0 | 0 | 0 | 0 | -0.57588373124599457,0,0 | 0.85458565969020128,2.6615136340260506,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.423Z | Line String | 5333563.7427981375,2184683.1861455264,5.6843418860808015e-14 | 0 | 0 | 0 | -0.57588373310863972,0,0 | 0.85458566062152386,2.6615136349573731,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.430Z | Line String | 5333562.2577526122,2184680.7672863347,0 | 0 | 0 | 0 | -0.57588373124599457,0,0 | 0.85458566062152386,2.6615136344917119,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.433Z | Line String | 5333562.8882124769,2184680.724560814,0 | 0 | 0 | 0 | -0.57588373310863972,0,0 | 0.85458565969020128,2.6615136349573731,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.438Z | Line String | 5333563.9669239325,2184685.6904557585,0 | 0 | 0 | 0 | -0.57588373124599457,0,0 | 0.85458565969020128,2.6615136340260506,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.444Z | Line String | 5333564.5973837972,2184685.6477302397,0 | 0 | 0 | 0 | -0.57588373310863972,0,0 | 0.85458566062152386,2.6615136335603893,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.449Z | Line String | 5333562.0336268162,2184678.2629761021,0 | 0 | 0 | 0 | -0.57588373031467199,0,0 | 0.85458566062152386,2.6615136340260506,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.453Z | Line String | 5333561.4031669535,2184678.3057016227,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.85458565969020128,2.6615136344917119,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.460Z | Line String | 5333564.8215095922,2184688.1520404709,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.71726381499320269,2.2659659800119698,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.464Z | Line String | 5333565.4519694569,2184688.1093149502,0 | 0 | 0 | 0 | -0.57588373403996229,0,0 | 0.66268768161535263,2.1087625781074166,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.468Z | Line String | 5333561.316363004,2184676.196939046,0 | 0 | 0 | 0 | -0.57588373403996229,0,0 | 0.71726381313055754,2.2659659790806472,0
Bearing1 | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:11:15.476Z; User Label: Bearing1; Origin: 5333558.6407764573,2184668.7370448834,0; Yaw: 70.8546; Pitch: 0; Roll: 0; Bounding Box Low: -0.007112633902579546,-0.0024384042714145964,0; Bounding Box High: 0.007112633902579546,0.0024384054822049108,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.482Z | Line String | 5333560.1645955388,2184676.5967968893,0 | 0 | 0 | 0 | 0,-0.39985784469172359,0 | 5.9500615997239947,13.821209561079741,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.486Z | Line String | 5333564.1392718954,2184686.1868910789,0 | 0 | 0 | 0 | -0.67883669026196003,-0.67883479967713356,0 | 0.35839814506471157,0.029438958968967199,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.490Z | Line String | 5333562.1399815846,2184680.4280541395,0 | 0 | 0 | 0 | -0.35844719223678112,-0.029486918356269598,0 | 2.3577367030084133,5.7883241437375546,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.495Z | Line String | 5333562.6615309091,2184687.5065328386,0 | 0 | 0 | 0 | -2.4991115294396877,-8.3981201807036996,0 | 3.4553023902699351,0,4.4906300900038332e-12
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.500Z | Line String | 5333565.4272575872,2184685.9727944722,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.21543244365602732,0.10439745057374239,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.504Z | Line String | 5333565.4837485151,2184685.856220948,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.11298185680061579,0,0 | 0,0.23314704885706306,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.510Z | Line String | 5333565.6991809597,2184685.9606183991,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.11298185773193836,0,0 | 0,0.23314704839140177,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.514Z | Line String | 5333565.7195714135,2184686.1144482428,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.17998073995113373,0.087217737920582294,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.520Z | Line String | 5333565.8995521534,2184686.2016659807,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.053716959431767464,-0.0038063609972596169,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.526Z | Line String | 5333565.8995521534,2184686.2016659807,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.036273411475121975,-0.039802509360015392,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.531Z | Line String | 5333565.281514395,2184684.9299495574,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513596206903458,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.535Z | Line String | 5333565.3239992065,2184685.0523246056,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969622083008289,-0.24475009692832828,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.539Z | Line String | 5333565.0978453178,2184685.1308382023,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.546Z | Line String | 5333565.3622219395,2184684.9019304076,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.065593346953392029,0 | 0.18893785402178764,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.550Z | Line String | 5333565.5511597935,2184684.8363370607,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.040675127878785133,0,0 | 0,0.035292122513055801,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.554Z | Line String | 5333565.5511597935,2184684.8363370607,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.053793796338140965,-0.0024954476393759251,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.559Z | Line String | 5333564.9149780367,2184683.8741627168,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513596672564745,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.564Z | Line String | 5333564.9574628482,2184683.996537765,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969622083008289,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.569Z | Line String | 5333564.7313089594,2184684.0750513626,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969623014330864,-0.24475009692832828,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.573Z | Line String | 5333564.995685582,2184683.8461435661,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.065593346953392029,0 | 0.18893785495311022,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.580Z | Line String | 5333565.184623437,2184683.7805502191,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.040675127878785133,0,0 | 0,0.035292123444378376,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.585Z | Line String | 5333565.184623437,2184683.7805502191,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.053793799132108688,-0.0024954481050372124,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.589Z | Line String | 5333564.5484416811,2184682.8183758738,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388873964548,0,0 | 0,0.078513596672564745,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.596Z | Line String | 5333564.5909264907,2184682.9407509221,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.601Z | Line String | 5333564.3647726029,2184683.0192645197,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009785965085,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.606Z | Line String | 5333564.6291492237,2184682.7903567236,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.065593346953392029,0 | 0.18893785588443279,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.611Z | Line String | 5333564.8180870796,2184682.7247633766,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.040675128810107708,0,0 | 0,0.035292122513055801,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.615Z | Line String | 5333564.8180870796,2184682.7247633766,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.053793799132108688,-0.0024954481050372124,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.619Z | Line String | 5333564.1819053227,2184681.7625890337,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388873964548,0,0 | 0,0.07851359760388732,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.623Z | Line String | 5333564.2243901324,2184681.8849640824,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009692832828,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.631Z | Line String | 5333563.9982362445,2184681.9634776786,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.635Z | Line String | 5333564.2626128662,2184681.734569883,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.065593346953392029,0 | 0.18893785402178764,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.639Z | Line String | 5333564.4515507203,2184681.668976536,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.040675127878785133,0,0 | 0,0.035292122513055801,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.644Z | Line String | 5333564.4515507203,2184681.668976536,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.053793797269463539,-0.0024954481050372124,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.650Z | Line String | 5333563.8153689662,2184680.7068021917,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615389060229063,0,0 | 0,0.078513596206903458,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.654Z | Line String | 5333563.8578537758,2184680.8291772394,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969623014330864,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.659Z | Line String | 5333563.6316998871,2184680.9076908366,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969622083008289,-0.2447500959970057,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.665Z | Line String | 5333563.8960765088,2184680.6787830414,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.065593346953392029,0 | 0.18893785402178764,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.670Z | Line String | 5333564.0850143628,2184680.6131896945,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.040675127878785133,0,0 | 0,0.035292122513055801,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.676Z | Line String | 5333564.0850143628,2184680.6131896945,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.053793797269463539,-0.0024954481050372124,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.680Z | Line String | 5333563.3879543878,2184679.5825559273,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.10439745150506496,0,0 | 0,0.2154324441216886,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.685Z | Line String | 5333563.5045279115,2184679.6390468553,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.23314704652875662,-0.11298185726627707,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.690Z | Line String | 5333563.4001304628,2184679.8544792999,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.23314705025404692,-0.11298185773193836,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.695Z | Line String | 5333563.4252107097,2184679.5056745438,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.17998073901981115,0 | 0.087217737920582294,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.699Z | Line String | 5333563.5124284476,2184679.3256938048,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.0038063600659370422,0,0 | 0,0.053716958966106176,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.703Z | Line String | 5333563.5124284476,2184679.3256938048,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.039802508428692818,0,0 | 0,0.036273411475121975,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.709Z | Line String | 5333564.1999786142,2184686.3617563285,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.078513596206903458,0.22615388780832291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.714Z | Line String | 5333564.322353662,2184686.3192715179,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.718Z | Line String | 5333564.4008672591,2184686.5454254057,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.722Z | Line String | 5333564.3065113602,2184686.6686177612,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.065593346953392029,0.18893785448744893,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.729Z | Line String | 5333564.3721047072,2184686.8575556157,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.035292121581733227,-0.040675127878785133,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.734Z | Line String | 5333564.3721047072,2184686.8575556157,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.053793798200786114,0 | 0.0024954481050372124,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.738Z | Line String | 5333563.8334422559,2184685.3059694869,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388827398419,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.745Z | Line String | 5333563.9558173046,2184685.2634846764,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.751Z | Line String | 5333564.0343309017,2184685.4896385642,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.755Z | Line String | 5333563.4669058984,2184684.2501826454,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388873964548,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.762Z | Line String | 5333563.5892809471,2184684.2076978348,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.767Z | Line String | 5333563.6677945442,2184684.4338517236,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.773Z | Line String | 5333563.100369541,2184683.1943958043,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388734266162,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.780Z | Line String | 5333563.2227445897,2184683.1519109933,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.784Z | Line String | 5333563.3012581859,2184683.3780648811,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009553134441,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.788Z | Line String | 5333562.7338331835,2184682.1386089632,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388780832291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.794Z | Line String | 5333562.8562082313,2184682.0961241527,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009553134441,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.799Z | Line String | 5333562.9347218294,2184682.3222780405,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.803Z | Line String | 5333562.3672968261,2184681.0828221207,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.078513596206903458,0.22615388873964548,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.807Z | Line String | 5333562.4896718748,2184681.0403373102,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009739398956,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.813Z | Line String | 5333562.5681854719,2184681.2664911994,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009832531214,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.817Z | Line String | 5333562.0007604677,2184680.0270352801,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388780832291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.821Z | Line String | 5333562.1231355174,2184679.9845504696,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009832531214,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.827Z | Line String | 5333562.2016491126,2184680.2107043574,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.832Z | Line String | 5333561.9727413189,2184679.9463277357,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.065593347884714603,-0.18893785402178764,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.837Z | Line String | 5333561.907147971,2184679.7573898816,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.035292122513055801,0.040675127878785133,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.843Z | Line String | 5333561.907147971,2184679.7573898816,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.0024954481050372124,0,0 | 0,0.053793797735124826,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.855Z | Line String | 5333562.9956957418,2184686.8169571254,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.10439745150506496,0,0 | 0,0.21543244458734989,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.861Z | Line String | 5333563.1122692656,2184686.8734480543,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.23314704932272434,-0.11298185680061579,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.865Z | Line String | 5333563.007871815,2184687.0888804989,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.23314704932272434,-0.1129818563349545,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.869Z | Line String | 5333562.8540419694,2184687.1092709526,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.08721773698925972,0,0 | 0,0.17998073901981115,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.873Z | Line String | 5333562.7668242324,2184687.2892516917,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.053716957569122314,0 | 0.0038063600659370422,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.879Z | Line String | 5333562.7668242324,2184687.2892516917,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.0362734105437994,0 | 0.039802507497370243,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.883Z | Line String | 5333562.6900376035,2184685.8296297081,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388873964548,0,0 | 0,0.078513596672564745,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.887Z | Line String | 5333562.7325224131,2184685.9520047558,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.2447500959970057,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.893Z | Line String | 5333562.5063685263,2184686.030518353,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969622083008289,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.898Z | Line String | 5333562.3831761703,2184685.9361624541,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.18893785495311022,0,0 | 0,0.065593347884714603,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.902Z | Line String | 5333562.1942383153,2184686.001755802,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.035292121581733227,0 | 0.040675128810107708,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.907Z | Line String | 5333562.1942383153,2184686.001755802,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.053793798200786114,0.0024954481050372124,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.913Z | Line String | 5333562.3235012442,2184684.773842867,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.919Z | Line String | 5333562.3659860548,2184684.8962179157,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.923Z | Line String | 5333562.1398321679,2184684.9747315128,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969623945653439,-0.2447500959970057,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.929Z | Line String | 5333562.0166398119,2184684.8803756125,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.18893785402178764,0,0 | 0,0.065593347884714603,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.934Z | Line String | 5333561.8277019579,2184684.9459689604,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.035292121581733227,0 | 0.040675128810107708,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.939Z | Line String | 5333561.8277019579,2184684.9459689604,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.053793797269463539,0.002495449036359787,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.946Z | Line String | 5333561.9569648877,2184683.7180560241,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.951Z | Line String | 5333561.9994496983,2184683.8404310727,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.08496962022036314,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.955Z | Line String | 5333561.7732958104,2184683.9189446699,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009692832828,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.963Z | Line String | 5333561.6501034554,2184683.824588771,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.18893785495311022,0,0 | 0,0.065593346953392029,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.968Z | Line String | 5333561.4611656005,2184683.8901821179,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.035292122513055801,0 | 0.040675128810107708,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.973Z | Line String | 5333561.4611656005,2184683.8901821179,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.053793798200786114,0.0024954495020210743,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.982Z | Line String | 5333561.5904285293,2184682.6622691844,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388687700033,0,0 | 0,0.078513596206903458,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.986Z | Line String | 5333561.6329133399,2184682.7846442331,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.08496962022036314,-0.24475009739398956,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.993Z | Line String | 5333561.4067594521,2184682.8631578293,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:15.998Z | Line String | 5333561.283567098,2184682.7688019308,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.18893785495311022,0,0 | 0,0.065593346487730742,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.004Z | Line String | 5333561.094629243,2184682.8343952773,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.035292122513055801,0 | 0.040675128810107708,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.011Z | Line String | 5333561.094629243,2184682.8343952773,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.053793799132108688,0.002495449036359787,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.015Z | Line String | 5333561.2238921709,2184681.6064823424,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.22615388687700033,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.019Z | Line String | 5333561.2663769815,2184681.728857391,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.026Z | Line String | 5333561.0402230937,2184681.8073709882,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.084969623014330864,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.032Z | Line String | 5333560.9170307387,2184681.7130150879,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.18893785402178764,0,0 | 0,0.065593348350375891,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.036Z | Line String | 5333560.7280928846,2184681.7786084362,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,-0.035292122047394514,0 | 0.040675128810107708,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.040Z | Line String | 5333560.7280928846,2184681.7786084362,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.053793798200786114,0.0024954485706984997,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.046Z | Line String | 5333560.6365626482,2184680.5377535746,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.21543244458734989,0.10439745057374239,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.050Z | Line String | 5333560.6930535771,2184680.4211800499,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.11298185493797064,0,0 | 0,0.23314704932272434,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.054Z | Line String | 5333560.9084860217,2184680.5255775005,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.11298185680061579,0,0 | 0,0.23314704978838563,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.061Z | Line String | 5333560.5596812647,2184680.5004972527,-2.2204460492503131e-16 | 0 | 0 | 0 | -0.179980737157166,-0.087217737920582294,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.067Z | Line String | 5333560.3797005275,2184680.4132795148,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.05371695663779974,0.0038063609972596169,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.071Z | Line String | 5333560.3797005275,2184680.4132795148,-2.2204460492503131e-16 | 0 | 0 | 0 | 0,0,0 | 0.036273409612476826,0.039802509360015392,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.078Z | Line | 5333590.9430375956,2184673.6182515319,0 | 0 | 0 | 0 | 0,0,0 | 6.9974982896819711,20.155890297610313,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.082Z | Line | 5333590.5111247972,2184673.7681982233,0 | 0 | 0 | 0 | 0,0,0 | 6.9974982896819711,20.155890297610313,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.088Z | Line String | 5333596.2387359766,2184689.5612977566,0 | 0 | 0 | 0 | -0.23937190137803555,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.094Z | Line String | 5333595.3841503169,2184687.0997130466,-5.6843418860808015e-14 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.1368683772161603e-13 | 0,0.72382092708721757,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.100Z | Line String | 5333594.5295646572,2184684.6381283333,0 | 0 | 0 | 0 | -0.23937190230935812,-0.0034095393493771553,0 | 0,0.72382092615589499,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.106Z | Line String | 5333593.6749789976,2184682.1765436204,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.113Z | Line String | 5333592.8203933388,2184679.7149589094,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.1368683772161603e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.117Z | Line String | 5333591.9658076782,2184677.253374198,5.6843418860808015e-14 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092708721757,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.122Z | Line String | 5333596.7252249084,2184689.5685544671,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,0 | 0,0.72382092662155628,1.7053025658242404e-13
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.128Z | Line String | 5333595.8706392469,2184687.1069697561,-5.6843418860808015e-14 | 0 | 0 | 0 | -0.23937190230935812,-0.0034095384180545807,0 | 0,0.72382092662155628,5.6843418860808015e-14
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.132Z | Line String | 5333595.0160535881,2184684.6453850446,0 | 0 | 0 | 0 | -0.23937190324068069,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.136Z | Line String | 5333594.1614679294,2184682.1838003336,0 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092708721757,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.142Z | Line String | 5333593.3068822687,2184679.7222156222,0 | 0 | 0 | 0 | -0.23937190137803555,-0.0034095393493771553,0 | 0,0.72382092615589499,1.1368683772161603e-13
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.148Z | Line String | 5333592.4522966091,2184677.260630908,-5.6843418860808015e-14 | 0 | 0 | 0 | -0.23937190230935812,-0.003409538883715868,-1.7053025658242404e-13 | 0,0.72382092662155628,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.152Z | Line String | 5333595.9077135948,2184688.6157377488,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.71726381499320269,2.2659659800119698,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.157Z | Line String | 5333595.0531279352,2184686.1541530374,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.85458565969020128,2.6615136340260506,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.164Z | Line String | 5333594.1985422764,2184683.692568325,0 | 0 | 0 | 0 | -0.57588373310863972,0,0 | 0.85458566062152386,2.6615136349573731,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.170Z | Line String | 5333593.3439566158,2184681.2309836131,0 | 0 | 0 | 0 | -0.57588373310863972,0,0 | 0.85458565969020128,2.6615136344917119,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.174Z | Line String | 5333592.4893709552,2184678.7693989011,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.85458566062152386,2.6615136340260506,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.181Z | Line String | 5333591.8266832735,2184676.8605652447,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.66268768254667521,2.1087625785730779,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.186Z | Line String | 5333595.6835877998,2184686.1114275181,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.85458565969020128,2.6615136335603893,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.191Z | Line String | 5333594.8290021382,2184683.6498428062,0 | 0 | 0 | 0 | -0.57588373124599457,0,0 | 0.85458566062152386,2.6615136344917119,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.196Z | Line String | 5333593.9744164795,2184681.1882580947,0 | 0 | 0 | 0 | -0.57588373217731714,0,0 | 0.85458565969020128,2.6615136335603893,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.201Z | Line String | 5333593.1198308207,2184678.7266733828,0 | 0 | 0 | 0 | -0.57588373310863972,0,0 | 0.85458565875887871,2.6615136344917119,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.205Z | Line String | 5333592.4025670039,2184676.6606363235,0 | 0 | 0 | 0 | -0.57588373031467199,0,0 | 0.71726381778717041,2.265965981874615,0
Bearing2 | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:11:16.214Z; User Label: Bearing2; Origin: 5333589.7269804589,2184669.2007421614,0; Yaw: 70.8546; Pitch: 0; Roll: 0; Bounding Box Low: -0.0073356577195227146,-0.0024384061340597457,0; Bounding Box High: 0.0073356591165065765,0.0024384036195597616,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.219Z | Line String | 5333591.2507995404,2184677.0604941673,0 | 0 | 0 | 0 | 0,-0.39985784469172359,0 | 5.9500616006553173,13.821209561079741,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.223Z | Line String | 5333595.225475898,2184686.6505883555,0 | 0 | 0 | 0 | -0.67883669026196003,-0.67883479874581099,0 | 0.358398144133389,0.029438958968967199,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.226Z | Line String | 5333593.2261855882,2184680.8917514156,0 | 0 | 0 | 0 | -0.35844719223678112,-0.029486918356269598,0 | 2.3577367020770907,5.7883241437375546,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.231Z | Line String | 5333593.7477349127,2184687.970230116,-5.6843418860808015e-14 | 0 | 0 | 0 | -2.4991115294396877,-8.3981201807036996,0 | 3.4553023912012577,0,2.4442670110147446e-12
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.235Z | Line String | 5333596.5134615898,2184686.4364917497,0 | 0 | 0 | 0 | 0,0,0 | 0.21543244551867247,0.10439745150506496,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.239Z | Line String | 5333596.5699525196,2184686.3199182246,0 | 0 | 0 | 0 | -0.11298185866326094,0,0 | 0,0.23314704932272434,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.244Z | Line String | 5333596.7853849623,2184686.4243156761,0 | 0 | 0 | 0 | -0.11298185680061579,0,0 | 0,0.23314704932272434,0
