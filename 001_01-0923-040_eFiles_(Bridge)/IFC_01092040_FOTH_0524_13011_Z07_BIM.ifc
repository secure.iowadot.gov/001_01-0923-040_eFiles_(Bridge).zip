Properties of the parts of a building model (IFC4X3_ADD2), part 11 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.910Z | Extended Element | 5333584.3765193177,2184676.486044554,360.894275661736 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.919Z | Extended Element | 5333584.6558887884,2184676.4902117681,360.89434756783072 | 0.854588 | 0.00000403579 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.935Z | Extended Element | 5333584.9352582693,2184676.4943789812,360.89436960385405 | 0.854588 | 0.00000356408 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.948Z | Extended Element | 5333585.2146277484,2184676.4985461957,360.89439051784609 | 0.854588 | 0.0000035676 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.959Z | Extended Element | 5333585.4939972293,2184676.5027134102,360.89441143183814 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.976Z | Extended Element | 5333585.5604601288,2184690.7801213525,360.89442871613272 | -179.145 | 0.0000091902 | -0.000003023 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:30.986Z | Extended Element | 5333585.8398296079,2184690.7842885666,360.89441955201187 | -179.145 | 0.00000244268 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.006Z | Extended Element | 5333586.3321056664,2184676.5152150528,360.89438790192895 | 0.854588 | 0.00000403931 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.017Z | Extended Element | 5333586.6114751417,2184676.5193822668,360.8943394955748 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.028Z | Extended Element | 5333586.8908446198,2184676.5235494808,360.89429108922064 | 0.854588 | 0.00000403931 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.036Z | Extended Element | 5333586.9573075166,2184690.8009574236,360.89424462746109 | -179.145 | 0.00000919015 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.044Z | Extended Element | 5333587.236676991,2184690.8051246381,360.89419622110711 | -179.145 | 0.00000243917 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.062Z | Extended Element | 5333587.7289530486,2184676.5360511225,360.89414172509515 | 0.854588 | 0.0000104129 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.073Z | Extended Element | 5333588.0083225053,2184676.5402183365,360.89403316252242 | 0.854588 | 0.0000035676 | 0.00000806982 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.081Z | Extended Element | 5333588.0747853853,2184690.8176262788,360.89392654454434 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.094Z | Extended Element | 5333588.5670614233,2184676.5485527636,360.89381603737706 | 0.854588 | 0.0000103622 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.103Z | Extended Element | 5333588.8464308837,2184676.5527199786,360.89370747480444 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.114Z | Extended Element | 5333589.1258003442,2184676.5568871922,360.89359891223177 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.133Z | Extended Element | 5333589.405169785,2184676.5610544058,360.89345339214719 | 0.854588 | 0.0000103151 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.146Z | Extended Element | 5333589.6845392138,2184676.5652216179,360.89328467337128 | 0.854588 | 0.0000035676 | 0.00000806984 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.158Z | Extended Element | 5333589.9639086425,2184676.5693888315,360.89311595459509 | 0.854588 | 0.00000403931 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.168Z | Extended Element | 5333590.2432780713,2184676.5735560446,360.89294723581924 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.181Z | Extended Element | 5333590.3097409224,2184690.8509639865,360.89278046163776 | -179.145 | 0.00000919019 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.199Z | Extended Element | 5333590.8020169241,2184676.5818904708,360.8926001845478 | 0.854588 | 0.00000356408 | 0.00000821968 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.211Z | Extended Element | 5333591.081386311,2184676.5860576839,360.89237130959151 | 0.854588 | 0.0000103623 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.220Z | Extended Element | 5333591.1478491174,2184690.8634656244,360.89214437922988 | -179.145 | 0.00000239198 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.231Z | Extended Element | 5333591.4272185061,2184690.867632838,360.89191550427381 | -179.145 | 0.0000091902 | -0.00000302299 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.242Z | Extended Element | 5333591.9194944706,2184676.5985593218,360.89168468472297 | 0.854588 | 0.00000403931 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.252Z | Extended Element | 5333591.9859572798,2184690.8759672642,360.89145775436128 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.273Z | Extended Element | 5333592.4782332052,2184676.6068937471,360.8911845087618 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.284Z | Extended Element | 5333592.5446959548,2184690.8843016867,360.89089742225173 | -179.145 | 0.00000239198 | -0.0000080457 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.297Z | Extended Element | 5333593.0369718662,2184676.615228171,360.89060644655262 | 0.854588 | 0.00000403579 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.310Z | Extended Element | 5333593.3163411962,2184676.6193953827,360.89031741544812 | 0.854588 | 0.0000103622 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.320Z | Extended Element | 5333593.595710529,2184676.6235625958,360.89002838434357 | 0.854588 | 0.0000035676 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.341Z | Extended Element | 5333593.8750798414,2184676.6277298066,360.88972427107956 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.351Z | Extended Element | 5333593.9415425248,2184690.9051377457,360.88937702846192 | -179.145 | 0.00000919015 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.362Z | Extended Element | 5333594.4338183682,2184676.6360642281,360.88902589665514 | 0.854588 | 0.00000403929 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.373Z | Extended Element | 5333594.5002810517,2184690.9134721677,360.88867865403756 | -179.145 | 0.0000091902 | -0.00000302299 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.383Z | Extended Element | 5333594.9925568914,2184676.6443986502,360.88832752223078 | 0.854588 | 0.00000403931 | 0.00000821969 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.395Z | Extended Element | 5333595.2719261553,2184676.6485658614,360.88797833501854 | 0.854588 | 0.0000103151 | 0.00000822096 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.413Z | Extended Element | 5333595.5512953512,2184676.6527330712,360.88758125351933 | 0.854588 | 0.0000103657 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.425Z | Extended Element | 5333595.6177579518,2184690.9301410089,360.8871738548425 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.434Z | Extended Element | 5333595.8971271338,2184690.9343082188,360.88676451157113 | -179.145 | 0.00000923734 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.446Z | Extended Element | 5333596.3894028934,2184676.6652346998,360.8863532237051 | 0.854588 | 0.0000035676 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.458Z | Extended Element | 5333596.455865493,2184690.9426426371,360.88594582502839 | -179.145 | 0.00000918668 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.476Z | Extended Element | 5333596.7352346405,2184690.946809846,360.88551593150481 | -179.145 | 0.00000239198 | -0.00000819553 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.487Z | Extended Element | 5333597.2275103079,2184676.6777363266,360.88504448763632 | 0.854588 | 0.0000103623 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.499Z | Extended Element | 5333597.5068793939,2184676.6819035346,360.88457498836215 | 0.854588 | 0.00000403929 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.510Z | Extended Element | 5333597.78624848,2184676.6860707435,360.88410548908809 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.520Z | Extended Element | 5333597.8527109865,2184690.9634786798,360.88363793440868 | -179.145 | 0.00000919015 | -0.0000080457 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.531Z | Extended Element | 5333598.3449866511,2184676.6944051594,360.88316649053985 | 0.854588 | 0.00000403579 | 0.0000082197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.549Z | Extended Element | 5333598.6243556431,2184676.6985723665,360.88264362917005 | 0.854588 | 0.0000103657 | 0.0000030484 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.563Z | Extended Element | 5333598.9037246192,2184676.7027395726,360.88211397395838 | 0.854588 | 0.00000356758 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.571Z | Extended Element | 5333598.9701870196,2184690.9801475075,360.88158626334149 | -179.145 | 0.00000919019 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.580Z | Extended Element | 5333599.4624625761,2184676.7110739858,360.88105466353539 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.590Z | Extended Element | 5333599.5289249755,2184690.9884819216,360.88052695291844 | -179.145 | 0.00000243917 | -0.00000804568 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.605Z | Extended Element | 5333600.0212004818,2184676.7194083985,360.8799693352459 | 0.854588 | 0.00000403929 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.615Z | Extended Element | 5333600.0876627611,2184690.996816332,360.87938146876576 | -179.145 | 0.00000919015 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.626Z | Extended Element | 5333600.5799381984,2184676.7277428084,360.87878971309624 | 0.854588 | 0.00000403579 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.634Z | Extended Element | 5333600.8593070554,2184676.7319100131,360.87819990202155 | 0.854588 | 0.0000103151 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.647Z | Extended Element | 5333600.9257693337,2184691.0093179462,360.87761203554129 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.657Z | Extended Element | 5333601.2051381925,2184691.0134851513,360.87702222446643 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.676Z | Extended Element | 5333601.4845069209,2184691.0176523537,360.8763735840476 | -179.145 | 0.00000913949 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.686Z | Extended Element | 5333601.9767822232,2184676.7485788278,360.87572167259714 | 0.854588 | 0.0000103623 | 0.00000821969 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.697Z | Extended Element | 5333602.0432443684,2184691.0259867595,360.87507365033571 | -179.145 | 0.00000919019 | -0.00000302362 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.709Z | Extended Element | 5333602.5355196716,2184676.7569132331,360.87442173888519 | 0.854588 | 0.00000356758 | 0.00000319761 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.718Z | Extended Element | 5333602.8148883982,2184676.7610804359,360.87377177202933 | 0.854588 | 0.00000403577 | 0.00000319762 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.735Z | Extended Element | 5333602.8813504661,2184691.0384883666,360.87309226489509 | -179.145 | 0.00000919015 | -0.0000080457 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.746Z | Extended Element | 5333603.3736256231,2184676.7694148393,360.87238019775208 | 0.854588 | 0.0000103623 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.758Z | Extended Element | 5333603.4400876211,2184691.0468227686,360.87167201979832 | -179.145 | 0.00000244268 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.768Z | Extended Element | 5333603.9323627781,2184676.7777492404,360.8709599526552 | 0.854588 | 0.0000035676 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.779Z | Extended Element | 5333604.2117313584,2184676.7819164414,360.8702498301069 | 0.854588 | 0.00000403929 | 0.000003197 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.797Z | Extended Element | 5333604.2781933472,2184691.0593243698,360.86953751184319 | -179.145 | 0.00000919015 | -0.0000080457 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.808Z | Extended Element | 5333604.5575617636,2184691.0634915684,360.8687672337042 | -179.145 | 0.00000924085 | -0.00000819555 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.819Z | Extended Element | 5333605.0498367613,2184676.7944180383,360.86799501097073 | 0.854588 | 0.00000403931 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.831Z | Extended Element | 5333605.3292051796,2184676.7985852365,360.8672247328318 | 0.854588 | 0.00000356408 | 0.00000806982 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.842Z | Extended Element | 5333605.6085735969,2184676.8027524343,360.86645445469276 | 0.854588 | 0.0000103658 | 0.00000806985 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.854Z | Extended Element | 5333605.6750354385,2184691.0801603617,360.86568612114843 | -179.145 | 0.00000924085 | -0.00000819554 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.874Z | Extended Element | 5333606.167310331,2184676.8110868302,360.86487694727555 | 0.854588 | 0.0000103657 | 0.00000304778 | -0.010874609909035533,1.1525019165908338e-10,-0.010874592699318467 | 0.010874595756799154,14.27482854916896,0.13622162592084128
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.883Z | Complex Chain | 5333550.9992313543,2184688.1561501171,360.93338002415521 | 0 | 0 | 0 | 0,-10.05730129731819,-1.3755130794379511e-06 | 0.15001958049833775,0,0.091820516646635042
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.914Z | Extended Element | 5333551.2399248788,2184678.1002013572,360.93377765837369 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.926Z | Extended Element | 5333551.519291657,2184678.1043685311,360.93500700893782 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.935Z | Extended Element | 5333551.7986584324,2184678.1085357047,360.93623635949155 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.946Z | Extended Element | 5333552.0780252069,2184678.1127028782,360.93746571006784 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.956Z | Extended Element | 5333552.3573919823,2184678.1168700522,360.93869506062265 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.966Z | Extended Element | 5333552.6367587578,2184678.1210372252,360.93992441117547 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.977Z | Extended Element | 5333552.9161255369,2184678.1252043997,360.94115376172914 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.986Z | Extended Element | 5333553.1954923132,2184678.1293715741,360.94238311230731 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:31.998Z | Extended Element | 5333553.4748590896,2184678.1335387477,360.94361246285575 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.008Z | Extended Element | 5333553.7542258641,2184678.1377059212,360.94484181342091 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.018Z | Extended Element | 5333554.0335926423,2184678.1418730947,360.94607116396048 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.029Z | Extended Element | 5333554.3129594186,2184678.1460402682,360.94730051453251 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.046Z | Extended Element | 5333554.5923262099,2184678.1502074432,360.9485263964238 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.056Z | Extended Element | 5333554.8716930812,2184678.1543746176,360.94973346452667 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.066Z | Extended Element | 5333555.1510599526,2184678.1585417925,360.95094053262642 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.075Z | Extended Element | 5333555.4304268276,2184678.1627089684,360.95214760073469 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.088Z | Extended Element | 5333555.7097937278,2184678.1668761447,360.95334866416317 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.097Z | Extended Element | 5333555.9891608208,2184678.1710433224,360.9545033724529 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.108Z | Extended Element | 5333556.2685279176,2184678.1752105011,360.95565808075332 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.117Z | Extended Element | 5333556.5478950115,2184678.1793776792,360.9568127890663 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.127Z | Extended Element | 5333556.8272621036,2184678.1835448579,360.9579674973711 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.136Z | Extended Element | 5333557.1066291984,2184678.1877120361,360.95912220565754 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.154Z | Extended Element | 5333557.3859964553,2184678.1918792166,360.96023720646184 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.165Z | Extended Element | 5333557.6653637923,2184678.196046399,360.961331760007 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.176Z | Extended Element | 5333557.9447311284,2184678.2002135823,360.9624263135513 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.185Z | Extended Element | 5333558.2240984645,2184678.2043807642,360.96352086709419 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.193Z | Extended Element | 5333558.5034658015,2184678.2085479465,360.96461542062104 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.210Z | Extended Element | 5333558.782833185,2184678.2127151289,360.96569761222491 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.218Z | Extended Element | 5333559.0622007502,2184678.2168823145,360.96673201085753 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.229Z | Extended Element | 5333559.3415683154,2184678.2210494997,360.96776640947377 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.240Z | Extended Element | 5333559.6209358834,2184678.2252166853,360.96880080809012 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.250Z | Extended Element | 5333559.9003034476,2184678.229383871,360.9698352067241 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.260Z | Extended Element | 5333560.1796710137,2184678.2335510566,360.97086960534381 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.278Z | Extended Element | 5333560.459038741,2184678.237718245,360.97185883239536 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.288Z | Extended Element | 5333560.738406525,2184678.2418854339,360.97283307595831 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.299Z | Extended Element | 5333561.0177743034,2184678.2460526214,360.97380731951563 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.310Z | Extended Element | 5333561.2971420884,2184678.2502198103,360.97478156309739 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.319Z | Extended Element | 5333561.5765098715,2184678.2543869996,360.97575580665028 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.337Z | Extended Element | 5333561.8558777124,2184678.258554189,360.97671222380438 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.348Z | Extended Element | 5333562.1352456976,2184678.2627213802,360.97762631216114 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.360Z | Extended Element | 5333562.4146136837,2184678.2668885724,360.97854040053517 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.369Z | Extended Element | 5333562.6939816689,2184678.2710557645,360.97945448890715 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.380Z | Extended Element | 5333562.9733496523,2184678.2752229567,360.98036857728033 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.390Z | Extended Element | 5333563.2527176375,2184678.2793901479,360.98128266563714 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.408Z | Extended Element | 5333563.5320857856,2184678.2835573424,360.98214611731987 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.418Z | Extended Element | 5333563.8114539599,2184678.2877245373,360.98300005037646 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.430Z | Extended Element | 5333564.090822136,2184678.2918917318,360.98385398342668 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.441Z | Extended Element | 5333564.3701903112,2184678.2960589258,360.9847079164611 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.451Z | Extended Element | 5333564.6495584883,2184678.3002261207,360.98556184950542 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.468Z | Extended Element | 5333564.9289267296,2184678.3043933162,360.98639249069618 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.479Z | Extended Element | 5333565.2082950855,2184678.308560513,360.98718626828156 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.490Z | Extended Element | 5333565.4876634376,2184678.3127277107,360.98798004588446 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.501Z | Extended Element | 5333565.7670317907,2184678.316894908,360.98877382349355 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.520Z | Extended Element | 5333566.0464001428,2184678.3210621052,360.98956760110821 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.531Z | Extended Element | 5333566.3257684959,2184678.3252293025,360.99036137872349 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.549Z | Extended Element | 5333566.6051370008,2184678.3293965016,360.99109905360825 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.562Z | Extended Element | 5333566.8845055196,2184678.3335637017,360.99183267565303 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.571Z | Extended Element | 5333567.1638740366,2184678.3377309022,360.99256629772464 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.584Z | Extended Element | 5333567.4432425527,2184678.3418981023,360.99329991979147 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.596Z | Extended Element | 5333567.7226110725,2184678.3460653014,360.99403354182249 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.613Z | Extended Element | 5333568.0019796621,2184678.350232502,360.99473840568027 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.623Z | Extended Element | 5333568.28134833,2184678.3543997048,360.99541187209275 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.633Z | Extended Element | 5333568.5607170006,2184678.3585669072,360.99608533849943 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.645Z | Extended Element | 5333568.8400856685,2184678.3627341092,360.99675880489508 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.654Z | Extended Element | 5333569.1194543364,2184678.3669013102,360.99743227127931 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.671Z | Extended Element | 5333569.3988230079,2184678.3710685126,360.99810432392229 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.680Z | Extended Element | 5333569.6781918192,2184678.3752357177,360.99871763458191 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.690Z | Extended Element | 5333569.9575606249,2184678.3794029211,360.99933094524579 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.699Z | Extended Element | 5333570.2369294306,2184678.3835701249,360.99994425587676 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.712Z | Extended Element | 5333570.5162982382,2184678.3877373287,361.00055756652955 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.720Z | Extended Element | 5333570.7956670467,2184678.3919045329,361.00117087719036 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.738Z | Extended Element | 5333571.075035925,2184678.3960717381,361.00174996259619 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.748Z | Extended Element | 5333571.3544048583,2184678.4002389438,361.00230311740853 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.758Z | Extended Element | 5333571.6337737907,2184678.4044061499,361.0028562722311 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.768Z | Extended Element | 5333571.9131427221,2184678.4085733555,361.00340942705304 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.778Z | Extended Element | 5333572.1925116563,2184678.4127405621,361.00396258187368 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.797Z | Extended Element | 5333572.4718806017,2184678.4169077678,361.00450885564004 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.809Z | Extended Element | 5333572.7512496486,2184678.4210749753,361.00500185455439 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.818Z | Extended Element | 5333573.0306186927,2184678.4252421828,361.0054948534767 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.830Z | Extended Element | 5333573.3099877397,2184678.4294093908,361.00598785237725 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.841Z | Extended Element | 5333573.5893567838,2184678.4335765988,361.00648085128938 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.851Z | Extended Element | 5333573.8687258279,2184678.4377438058,361.00697385020197 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.867Z | Extended Element | 5333574.1480949391,2184678.4419110147,361.00742715620498 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.876Z | Extended Element | 5333574.4274640856,2184678.4460782246,361.00785999915104 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.893Z | Extended Element | 5333574.7068332294,2184678.450245433,361.00829284207293 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.901Z | Extended Element | 5333574.9862023769,2184678.4544126424,361.00872568500949 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.913Z | Extended Element | 5333575.2655715216,2184678.4585798513,361.00915852794373 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.931Z | Extended Element | 5333575.5449406849,2184678.4627470607,361.00957902199747 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.943Z | Extended Element | 5333575.8243099172,2184678.466914271,361.00995170887359 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.952Z | Extended Element | 5333576.1036791485,2184678.4710814813,361.01032439576352 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.964Z | Extended Element | 5333576.3830483798,2184678.4752486921,361.01069708268079 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.975Z | Extended Element | 5333576.662417612,2184678.4794159024,361.01106976957095 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:32.986Z | Extended Element | 5333576.9417868434,2184678.4835831122,361.01144245645202 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.005Z | Extended Element | 5333577.2211561315,2184678.487750324,361.0117699823287 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.016Z | Extended Element | 5333577.5005254354,2184678.4919175347,361.01208251314227 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.027Z | Extended Element | 5333577.779894744,2184678.4960847469,361.01239504394044 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.037Z | Extended Element | 5333578.0592640471,2184678.5002519577,361.01270757475265 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.049Z | Extended Element | 5333578.3386333538,2184678.5044191694,361.01302010554878 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.067Z | Extended Element | 5333578.6180026783,2184678.5085863816,361.01331481919192 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.080Z | Extended Element | 5333578.8973720437,2184678.5127535937,361.0135671938794 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.091Z | Extended Element | 5333579.1767414091,2184678.5169208059,361.01381956854618 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.101Z | Extended Element | 5333579.4561107792,2184678.5210880185,361.01407194320319 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.111Z | Extended Element | 5333579.7354801428,2184678.5252552303,361.0143243178785 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.121Z | Extended Element | 5333580.01484951,2184678.5294224434,361.01457669256035 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.137Z | Extended Element | 5333580.2942189155,2184678.5335896555,361.01477843773125 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.149Z | Extended Element | 5333580.5735883294,2184678.5377568696,361.01497065623732 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.159Z | Extended Element | 5333580.852957746,2184678.5419240831,361.01516287474385 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
