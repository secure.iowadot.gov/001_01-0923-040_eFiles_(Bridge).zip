Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 39

# File
Description: ExchangeRequirement[Architecture, Structural, BuildingService]
File name: export.ifc
Time: 2025-09-30T12:16:05
Author: User
Organization: Organization
Written by: ODA SDAI 25.8

# IfcProject, MyProject
Description: Set common project information, site address, building name, etc

# IfcSite, Site
RefLatitude: 15, 18, 46, 448614; RefLongitude: -139, -37, -27, -842299; RefElevation: 0 m

# IfcBuildingElementProxy: <null> (7667)
In: Site
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [CivilDesignerProductsDynamic].[SupportLine\Supportline] | [CivilDesignerProductsDynamic].[SupportLine\Supportline] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.041Z; User Label: Line; Origin: 5333544.1221448043,2184668.7012898698,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 0,0,0; Bounding Box High: 9.9964261269196868,28.79412899678573,0; SupportLine - Name: Abut1; SupportLine Rule - <- DistanceAlong ->: 1028.73 us survey foot; Direction Mode: Skew; Length: 99.9998 us survey foot; Direction: 1.23665 rad; Station: 10+28.7300; Skew: 20 deg; Start Point: 5333544.1221448043,2184668.7012898698,0; Horizontal Offset: 0 us survey foot; Feature - Feature Definition: Supportline; Feature Name: Abut1
Line | [CivilDesignerProductsDynamic].[SupportLine\Supportline] | [CivilDesignerProductsDynamic].[SupportLine\Supportline] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.041Z; User Label: Line; Origin: 5333558.1414132761,2184668.9104082501,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 0,0,0; Bounding Box High: 9.9964261259883642,28.794128997251391,0; SupportLine - Name: Pier1; SupportLine Rule - <- DistanceAlong ->: 1074.73 us survey foot; Direction Mode: Skew; Length: 99.9998 us survey foot; Direction: 1.23665 rad; Station: 10+74.7300; Skew: 20 deg; Start Point: 5333558.1414132761,2184668.9104082501,0; Horizontal Offset: 0 us survey foot; Feature - Feature Definition: Supportline; Feature Name: Pier1
Line | [CivilDesignerProductsDynamic].[SupportLine\Supportline] | [CivilDesignerProductsDynamic].[SupportLine\Supportline] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.042Z; User Label: Line; Origin: 5333589.2276172778,2184669.374105528,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 0,0,0; Bounding Box High: 9.9964261269196868,28.79412899678573,0; SupportLine - Name: Pier2; SupportLine Rule - <- DistanceAlong ->: 1176.73 us survey foot; Direction Mode: Skew; Length: 99.9998 us survey foot; Direction: 1.23665 rad; Station: 11+76.7300; Skew: 20 deg; Start Point: 5333589.2276172778,2184669.374105528,0; Horizontal Offset: 0 us survey foot; Feature - Feature Definition: Supportline; Feature Name: Pier2
Line | [CivilDesignerProductsDynamic].[SupportLine\Supportline] | [CivilDesignerProductsDynamic].[SupportLine\Supportline] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.042Z; User Label: Line; Origin: 5333603.2468857495,2184669.5832239087,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 0,0,0; Bounding Box High: 9.9964261269196868,28.794128996320069,0; SupportLine - Name: Abut2; SupportLine Rule - <- DistanceAlong ->: 1222.73 us survey foot; Direction Mode: Skew; Length: 99.9998 us survey foot; Direction: 1.23665 rad; Station: 12+22.7300; Skew: 20 deg; Start Point: 5333603.2468857495,2184669.5832239087,0; Horizontal Offset: 0 us survey foot; Feature - Feature Definition: Supportline; Feature Name: Abut2
Smart Solid | [CivilDesignerProductsDynamic].[Deck\Deck] | Feature - Feature Definition: Deck; Feature Name: Deck1; [CivilDesignerProductsDynamic].[Deck\Deck] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.043Z; User Label: Smart Solid; Origin: 5333578.6827279655,2184683.5393243586,360.93698755397509; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: -31.416973794805205,-7.6583335176838343,-0.2518751526834489; Bounding Box High: 31.416974541877508,7.658354303326,0.25189446869249321; QTO_SideAreasAspect - TopGrossArea: 9001.29 us survey square foot; TopNetArea: 9001.29 us survey square foot; Solid - Surface Area: 18472.8 us survey square foot; Volume: 6520.02 ft³ (us survey); QTO_MaterialAspect - Material: Deck Concrete - CCS & PPCB Bridges; Deck - Chord Tolerance: 0.328083 us survey foot; Vertical Offset: -0.03 us survey foot; Start Station Offset: 1.5965 us survey foot; Max Dist Between Sections: 3.28083 us survey foot; End Station Offset: -1.5965 us survey foot; Template Orientation: Vertical; Horizontal Offset: 0 us survey foot; Template: BTB Deck - 44' (w/6' Crown); Variable Constraint: SELECT to Edit; Point Control: SELECT to Edit; Name: Deck1; Template Name: BTB Deck - 44' (w/6' Crown); Analytical Deck: yes; Top Surface Area: 9001.29 us survey square foot; Start Station: 169+37.5965; End Station: 171+28.4035; Deck Breakbacks - Right End Breakback Distance: 1.58333 us survey foot; Left Start Breakback Distance: 1.58333 us survey foot; Left End Breakback Distance: 1.58333 us survey foot; Right Start Breakback Distance: 1.58333 us survey foot; Material - Deck Material: Deck Concrete - CCS & PPCB Bridges; Build Order - Deck Build Order: 0; QTO_SurfaceAreaAspect - GrossSurfaceArea: 18472.8 us survey square foot; NetSurfaceArea: 18472.8 us survey square foot; QTO_VolumeAspect - GrossVolume: 6520.02 ft³ (us survey); NetVolume: 6520.02 ft³ (us survey)
Civil Custom Graphics | [CivilDesignerProductsDynamic].[Deck\Deck] | Feature - Feature Definition: Deck; Feature Name: Deck1; [CivilDesignerProductsDynamic].[Deck\Deck] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.043Z; User Label: Civil Custom Graphics; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; QTO_SideAreasAspect - TopGrossArea: 9001.29 us survey square foot; TopNetArea: 9001.29 us survey square foot; Solid - Surface Area: 18472.8 us survey square foot; Volume: 6520.02 ft³ (us survey); QTO_MaterialAspect - Material: Deck Concrete - CCS & PPCB Bridges; Deck - Chord Tolerance: 0.328083 us survey foot; Vertical Offset: -0.03 us survey foot; Start Station Offset: 1.5965 us survey foot; Max Dist Between Sections: 3.28083 us survey foot; End Station Offset: -1.5965 us survey foot; Template Orientation: Vertical; Horizontal Offset: 0 us survey foot; Template: BTB Deck - 44' (w/6' Crown); Variable Constraint: SELECT to Edit; Point Control: SELECT to Edit; Name: Deck1; Template Name: BTB Deck - 44' (w/6' Crown); Analytical Deck: yes; Top Surface Area: 9001.29 us survey square foot; Start Station: 169+37.5965; End Station: 171+28.4035; Deck Breakbacks - Right End Breakback Distance: 1.58333 us survey foot; Left Start Breakback Distance: 1.58333 us survey foot; Left End Breakback Distance: 1.58333 us survey foot; Right Start Breakback Distance: 1.58333 us survey foot; Material - Deck Material: Deck Concrete - CCS & PPCB Bridges; Build Order - Deck Build Order: 0; QTO_SurfaceAreaAspect - GrossSurfaceArea: 18472.8 us survey square foot; NetSurfaceArea: 18472.8 us survey square foot; QTO_VolumeAspect - GrossVolume: 6520.02 ft³ (us survey); NetVolume: 6520.02 ft³ (us survey)
Civil Custom Graphics | [CivilDesignerProductsDynamic].[Beam\Girder] | Feature - Feature Definition: Girder; Feature Name: BeamGroup1; [CivilDesignerProductsDynamic].[Beam\Girder] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.044Z; User Label: Civil Custom Graphics; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; Beam Group Properties - Use Beam Rotation: no; Construct Wet Joints: no; Follow Left Deck Edge: no; End Cut Orientation: Vertical; Follow Right Deck Edge: no; Wet Joint Ends Normal: no; Beam Definition: SELECT to Edit; Start Cut Orientation: Vertical; Build Order - Beam Group Build Order: 0
Smart Solid | [CivilDesignerProductsDynamic].[Barrier\Barrier] | Feature - Feature Definition: Barrier; Feature Name: Barrier1; Solid - Surface Area: 1650.92 us survey square foot; Volume: 675.015 ft³ (us survey); Barrier - Chord Tolerance: 0.328083 us survey foot; Vertical Offset: 0 us survey foot; Start Station Offset: -0.776 us survey foot; End Station Offset: 0.776 us survey foot; Template Orientation: Vertical; Placement Surface: 0; Point Control Path: SELECT to Edit; Template: TSS TL-4 L; Horizontal Offset: 0 us survey foot; Pay Unit: Linear Unit; Max Dist Between Sections: 3.28083 us survey foot; Pay Unit Text: LF; End Cut Orientation: Normal to Path; Variable Constraint: SELECT to Edit; Point Control: SELECT to Edit; Start Cut Orientation: Normal to Path; Name: Barrier1; Description: BU01; Template Name: TSS TL-4 L; Length: 192.359 us survey foot; [CivilDesignerProductsDynamic].[Barrier\Barrier] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.045Z; User Label: Smart Solid; Origin: 5333581.01986284,2184690.4964592326,361.5051968503937; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: -29.316732069552803,-0.65431250212663949,-0.52393625112748377; Bounding Box High: 29.316740967763806,0.65432831753586529,0.52352620491784574; Build Order - Build Order: 0
Smart Solid | [CivilDesignerProductsDynamic].[Barrier\Barrier] | Feature - Feature Definition: Barrier; Feature Name: Barrier2; Solid - Surface Area: 1650.92 us survey square foot; Volume: 675.113 ft³ (us survey); Barrier - Chord Tolerance: 0.328083 us survey foot; Vertical Offset: 0 us survey foot; Start Station Offset: -0.776 us survey foot; End Station Offset: 0.776 us survey foot; Template Orientation: Vertical; Placement Surface: 0; Point Control Path: SELECT to Edit; Template: TSS TL-4 R; Horizontal Offset: 0 us survey foot; Pay Unit: Linear Unit; Max Dist Between Sections: 3.28083 us survey foot; Pay Unit Text: LF; End Cut Orientation: Normal to Path; Variable Constraint: SELECT to Edit; Point Control: SELECT to Edit; Start Cut Orientation: Normal to Path; Name: Barrier2; Description: BU01; Template Name: TSS TL-4 R; Length: 192.359 us survey foot; [CivilDesignerProductsDynamic].[Barrier\Barrier] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.046Z; User Label: Smart Solid; Origin: 5333576.3455930911,2184676.5821742443,361.49445262890526; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: -29.316740216694164,-0.65431901854884422,-0.53466969407496534; Bounding Box High: 29.316732818920187,0.65432180098049297,0.53427042640635358; Build Order - Build Order: 0
Cell | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.928Z | Cell | 0,0,0 | 0 | 0 | 0 | 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308 | -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308
Shape | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.928Z | Shape | 5333567.3484820947,2184677.879433082,0 | 0 | 0 | 0 | 0,0,0 | 2.2860045712441206,3.8100076196715236,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.928Z | Line | 5333568.8724851431,2184681.6894407016,0 | 0 | 0 | 0 | 0,0,0 | 0,3.2004064009524882,0
Shape | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.928Z | Shape | 5333567.3484820947,2184684.8898471026,0 | 0 | 0 | 0 | 0,0,0 | 2.2860045712441206,3.8100076201371849,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.928Z | Line | 5333568.1104836194,2184681.6894407016,0 | 0 | 0 | 0 | 0,0,0 | 0,3.2004064009524882,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.928Z | Line | 5333568.4914843813,2184677.879433082,0 | 0 | 0 | 0 | 0,0,0 | 0,10.820421640761197,0
Cell | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.954Z | Cell | 0,0,0 | 0 | 0 | 0 | 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308 | -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308
Shape | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.954Z | Shape | 5333588.6634113481,2184678.1980567151,0 | 0 | 0 | 0 | 0,0,0 | 2.2860045721754432,3.8100076201371849,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.954Z | Line | 5333590.1874143966,2184682.0080643352,0 | 0 | 0 | 0 | 0,0,0 | 0,3.2004064009524882,0
Shape | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.954Z | Shape | 5333588.6634113481,2184685.2084707362,0 | 0 | 0 | 0 | 0,0,0 | 2.2860045721754432,3.8100076201371849,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.954Z | Line | 5333589.4254128728,2184682.0080643352,0 | 0 | 0 | 0 | 0,0,0 | 0,3.2004064009524882,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:49.954Z | Line | 5333589.8064136347,2184678.1980567151,0 | 0 | 0 | 0 | 0,0,0 | 0,10.820421641226858,0
Bearing Element: Bearing2 | [CivilDesignerProductsDynamic].[Bearing\Bearing] | Feature - Feature Definition: Bearing; Feature Name: Bearing2; [CivilDesignerProductsDynamic].[Bearing\Bearing] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.047Z; User Label: Bearing Element: Bearing2; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; Rule Property - Ahead Offset: 0.75 us survey foot; Model Stepped Cap: yes; Model As Sloped Bearing Seats: no; Back Offset: -0.75 us survey foot; Active Angle: 0 deg; Has Pad or Plate: no; Has Bearing Seats: yes; Seat Min Thickness: 0 us survey foot; Bearing Orientation: Girder; Bearing Type: Cube; Seat Orientation: Pier; Grout Pad Orientation: Girder; Pad Thickness Definition: At Center; Bearing Pay Unit: 3; Pad or Plate Pay Unit: 3; Cube Width, W: 2.375 us survey foot; Cube Depth, D: 0.75 us survey foot; Cube Height: 0.0833 us survey foot; Bearing Group - Name: Bearing2; Description: BU01; Material - Pad or Plate Material: Neoprene Bearing Pads; Bearing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Bearing Seat Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Build Order - Pad or Plate Build Order: 0; Bearing Build Order: 0; Beam Seat Build Order: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.046Z | Smart Solid | 5333596.1190449577,2184689.9215138429,359.87426974853946 | 0 | 0 | 0 | -0.11968088337947697,-0.36362562497376016,-0.012701929809982155 | 0.11969101895141798,0.36360484035685658,0.012687960969799406 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing1; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.068Z | Smart Solid | 5333595.2644602489,2184687.4599136398,359.92447040894081 | 0 | 0 | 0 | -0.11968183332839941,-0.36361013149802923,-0.012680873113613395 | 0.11969006902439563,0.36362033383920789,0.012709017666168165 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing2; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.092Z | Smart Solid | 5333594.4098755391,2184684.9983439166,359.97457962915922 | 0 | 0 | 0 | -0.11968278420879916,-0.36362512252858992,-0.012680598361459922 | 0.11968911813320685,0.36360534280538559,0.012709292418321638 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing3; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.111Z | Smart Solid | 5333593.5552908303,2184682.5367437135,359.97564643129283 | 0 | 0 | 0 | -0.11968373415772465,-0.36360963184663198,-0.012693887793222964 | 0.1196881682055376,0.36362083349376917,0.012696002986558597 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing4; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.132Z | Smart Solid | 5333592.7007061215,2184680.0751739903,359.92764033528067 | 0 | 0 | 0 | -0.11968468410675076,-0.36362461962082526,-0.012690261329698822 | 0.11968721825651149,0.36360584571957588,0.012699629450082739 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing5; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.154Z | Smart Solid | 5333591.8461214118,2184677.6135737873,359.87954279908558 | 0 | 0 | 0 | -0.11968563591857684,-0.36360912752557639,-0.012707416883149542 | 0.11968626641199635,0.36362133780494332,0.012682473896632018 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing6; Solid - Surface Area: 4.08313 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.176Z | Smart Solid | 5333596.6055372106,2184689.9287680974,359.87350774701548 | 0 | 0 | 0 | -0.11968420261319279,-0.36362316860664523,-0.012685136179659346 | 0.11968769970505067,0.36360729672014713,0.012704754600122214 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing7; Solid - Surface Area: 4.08313 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.199Z | Smart Solid | 5333595.7509525018,2184687.4671678944,359.9237998475997 | 0 | 0 | 0 | -0.1196851572189449,-0.36360767697970675,-0.012694087386780645 | 0.1196867450753748,0.36362278833985329,0.012695803393000915 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing8; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.220Z | Smart Solid | 5333594.896367793,2184685.0055981711,359.97397002794003 | 0 | 0 | 0 | -0.11968610809918379,-0.36362266476091643,-0.012693340297023476 | 0.11968579421834587,0.36360780056566,0.012696550482758084 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing9; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.244Z | Smart Solid | 5333594.0417830832,2184682.5439979681,359.97509779019555 | 0 | 0 | 0 | -0.11968705711677069,-0.36360717268299669,-0.012706157400220925 | 0.11968484522539635,0.36362329265102744,0.012683733379560636 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing10; Solid - Surface Area: 4.08312 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.265Z | Smart Solid | 5333593.1871983744,2184680.0824282449,359.9271526543053 | 0 | 0 | 0 | -0.11968800799723267,-0.36362216138128078,-0.012702058653492238 | 0.11968389432101079,0.36360830394551158,0.012687832126289322 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing11; Solid - Surface Area: 4.08313 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.285Z | Smart Solid | 5333592.3326136647,2184677.6208280413,359.87908559817117 | 0 | 0 | 0 | -0.11968895701504267,-0.36360667208308051,-0.012688261834587117 | 0.11968294528070447,0.3636237932369113,0.012701628945194443 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing12; Solid - Surface Area: 4.08313 us survey square foot; Volume: 0.148378 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.318Z | Smart Solid | 5333595.1924815848,2184687.4849072895,359.8862484124968 | 0 | 0 | 0 | -0.71523738056525588,-1.3307542520332336,-0.025525801661014522 | 0.7152320109307766,1.3307593820966781,0.025541123330299342 | Solid - Surface Area: 37.7303 us survey square foot; Volume: 2.8646 ft³ (us survey); General - Bearing: Bearing2; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.167542 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.167542 us survey foot; Depth at D1W2: 0.167542 us survey foot; Depth at D2W1: 0.167542 us survey foot; Depth at D2W2: 0.167542 us survey foot; Top Elevation: 1180.81 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.338Z | Smart Solid | 5333594.337896876,2184685.0233223266,359.91130302260603 | 0 | 0 | 0 | -0.71523833145104354,-1.3307540015101806,-0.05058041177026118 | 0.71523106098175049,1.3307596335564926,0.050596008191746478 | Solid - Surface Area: 41.1988 us survey square foot; Volume: 5.67549 ft³ (us survey); General - Bearing: Bearing3; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.331943 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.331943 us survey foot; Depth at D1W2: 0.331943 us survey foot; Depth at D2W1: 0.331943 us survey foot; Depth at D2W2: 0.331943 us survey foot; Top Elevation: 1180.97 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.359Z | Smart Solid | 5333593.4833121663,2184682.5617526034,359.91183642367281 | 0 | 0 | 0 | -0.7152392832627148,-1.3307689902129769,-0.051113812836914144 | 0.71523010917007923,1.3307446443853155,0.051116119826986051 | Solid - Surface Area: 41.2718 us survey square foot; Volume: 5.73459 ft³ (us survey); General - Bearing: Bearing4; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.335399 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.335399 us survey foot; Depth at D1W2: 0.335399 us survey foot; Depth at D2W1: 0.335399 us survey foot; Depth at D2W2: 0.335399 us survey foot; Top Elevation: 1180.98 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.381Z | Smart Solid | 5333592.6287122173,2184680.1001524003,359.88783337566673 | 0 | 0 | 0 | -0.7152249930491299,-1.330753499058932,-0.027110764830970316 | 0.71524439938366413,1.3307601350709797,0.02711669828426011 | Solid - Surface Area: 37.9491 us survey square foot; Volume: 3.04189 ft³ (us survey); General - Bearing: Bearing5; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.177911 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.177911 us survey foot; Depth at D1W2: 0.177911 us survey foot; Depth at D2W1: 0.177911 us survey foot; Depth at D2W2: 0.177911 us survey foot; Top Elevation: 1180.82 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.408Z | Smart Solid | 5333591.8700787397,2184677.9149606298,359.86378460756919 | 0 | 0 | 0 | -0.6192791981048138,-1.0543953844118492,-0.0030619967333917206 | 0.61929221637547016,1.0543671941734851,0.003050774633322817 | Solid - Surface Area: 26.863 us survey square foot; Volume: 0.265898 ft³ (us survey); General - Bearing: Bearing6; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.020055 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.020055 us survey foot; Depth at D1W2: 0.020055 us survey foot; Depth at D2W1: 0.020055 us survey foot; Depth at D2W2: 0.020055 us survey foot; Top Elevation: 1180.66 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.430Z | Smart Solid | 5333595.8229311658,2184687.4421894844,359.88591313182627 | 0 | 0 | 0 | -0.71522709783270955,-1.3307619657124579,-0.025190520990447184 | 0.71524229366332293,1.330751667949073,0.025192628386719207 | Solid - Surface Area: 37.683 us survey square foot; Volume: 2.82624 ft³ (us survey); General - Bearing: Bearing8; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.165299 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.165299 us survey foot; Depth at D1W2: 0.165299 us survey foot; Depth at D2W1: 0.165299 us survey foot; Depth at D2W2: 0.165299 us survey foot; Top Elevation: 1180.81 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.453Z | Smart Solid | 5333594.9683616962,2184684.9805892813,359.91099822199641 | 0 | 0 | 0 | -0.71524328887566924,-1.3307464750240743,-0.050275611160623623 | 0.71522610262036324,1.3307671595742181,0.050278465646385939 | Solid - Surface Area: 41.1558 us survey square foot; Volume: 5.64058 ft³ (us survey); General - Bearing: Bearing9; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.329901 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.329901 us survey foot; Depth at D1W2: 0.329901 us survey foot; Depth at D2W1: 0.329901 us survey foot; Depth at D2W2: 0.329901 us survey foot; Top Elevation: 1180.97 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.476Z | Smart Solid | 5333594.1137617473,2184682.5190195581,359.9115621031242 | 0 | 0 | 0 | -0.71522899959340691,-1.3307614632612097,-0.050839492288383956 | 0.71524039190262556,1.3307521704003216,0.050829529671091223 | Solid - Surface Area: 41.2329 us survey square foot; Volume: 5.70312 ft³ (us survey); General - Bearing: Bearing10; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.333559 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.333559 us survey foot; Depth at D1W2: 0.333559 us survey foot; Depth at D2W1: 0.333559 us survey foot; Depth at D2W2: 0.333559 us survey foot; Top Elevation: 1180.98 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.499Z | Smart Solid | 5333593.2591770384,2184680.0574193546,359.88758953517907 | 0 | 0 | 0 | -0.71522995047375559,-1.3307459716469423,-0.026866924343283589 | 0.71523944102227688,1.3307676629513503,0.026861060472640474 | Solid - Surface Area: 37.9145 us survey square foot; Volume: 3.01387 ft³ (us survey); General - Bearing: Bearing11; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.176273 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.176273 us survey foot; Depth at D1W2: 0.176273 us survey foot; Depth at D2W1: 0.176273 us survey foot; Depth at D2W2: 0.176273 us survey foot; Top Elevation: 1180.82 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.524Z | Smart Solid | 5333592.4732486662,2184677.793619507,359.86355600711198 | 0 | 0 | 0 | -0.64656539138831204,-1.1329831836630779,-0.0028333962762058726 | 0.64658215641975403,1.1329827981447056,0.0028413292246227684 | Solid - Surface Area: 29.0424 us survey square foot; Volume: 0.267173 ft³ (us survey); General - Bearing: Bearing12; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.0186178 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.0186178 us survey foot; Depth at D1W2: 0.0186178 us survey foot; Depth at D2W1: 0.0186178 us survey foot; Depth at D2W2: 0.0186178 us survey foot; Top Elevation: 1180.66 us survey foot; Pad or Plate Pay Unit: 3
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.774Z | Smart Solid | 5333563.1396342395,2184683.307477775,358.91186182372365 | 0 | 0 | 0 | -2.9750387014921049,-7.1105387304607373,-0.91440182880366727 | 2.9750228989869356,7.1105286753736436,0.91440182880364773 | Feature - Feature Definition: No Feature Definition; Feature Name: 1; Solid - Surface Area: 904.088 us survey square foot; Volume: 987 ft³ (us survey); Cap - Cap Type: Tapered; Station: 169+81.10000; Elevation Left: 1180.53 us survey foot; Length: 48 us survey foot; Width: 4 us survey foot; Height: 6 us survey foot; Left Taper Length: 13.75 us survey foot; Elevation Right: 1180.53 us survey foot; Fillet Radius: 0 us survey foot; Chamfer Length: 0 us survey foot; Minimum Height: 3 us survey foot; Right Taper Length: 13.75 us survey foot; Pier Cap - ItemTypes - Chamfer Length: 0 us survey foot; Width: 4 us survey foot; Elevation Left: 1180.53; Length: 48 us survey foot; Height: 6 us survey foot; Elevation Right: 1180.53; Fillet Radius: 0 us survey foot; Ledge Width: 0 us survey foot; Support Name: Pier1; Ledge Depth: 0 us survey foot; Minimum Height: 3 us survey foot; Left Delta: 13.75 us survey foot; Right Delta: 13.75 us survey foot; Volume: 987.006 ft3; Surface Area: 904.088 us survey square foot; Bottom Length: 49 us survey foot; Bottom Width: 3.5 us survey foot; Footing Offset: 0 us survey foot; BackWall Depth: 0 us survey foot; Horizontal Offset: 0 us survey foot; BackWall Width: 0 us survey foot; Vertical Offset: 0 us survey foot; Name: 1; Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Material - Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; General - Name: 1; Support Name: Pier1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:50.941Z | Smart Solid | 5333563.1396189993,2184683.307477775,354.1874676149352 | 0 | 0 | 0 | -1.5050732910862972,-3.055902342552943,-3.8112348904809723 | 1.5050879710404632,3.0558922891824274,3.8112044104203302 | Feature - Feature Definition: No Feature Definition; Feature Name: 1; Solid - Surface Area: 1234.62 us survey square foot; Volume: 1684.21 ft³ (us survey); Material - Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; General - Name: 1; Support Name: Pier1; Column - Length: 25 us survey foot; Column Type: Rect-Fillet; Overhang: 0 us survey foot; Top Elevation: 1174.53 us survey foot; Fillet Radius: 2.5 us survey foot; Overhang Type: Auto; Width: 20 us survey foot; Depth: 3.5 us survey foot; Pier Column - ItemTypes - Width: 20 us survey foot; Diameter Y: 0 us survey foot; Length: 25 us survey foot; Diameter X: 0 us survey foot; Diameter: 0 us survey foot; Depth: 3.5 us survey foot; Overhang: 0 us survey foot; Bevel X: 0 us survey foot; Bevel Y: 0 us survey foot; Fillet Radius: 2.5 us survey foot; Chamfer Length: 0 us survey foot; Top Elevation: 1174.53 us survey foot; Volume: 1684.22 ft3; Surface Area: 1234.62 us survey square foot; Support Name: Pier1; Name: 1; Material: Structural Concrete (Bridge) - CCS & PPCB Bridges
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:51.331Z | Smart Solid | 5333563.1396342395,2184683.307477775,349.76785877571751 | 0 | 0 | 0 | -2.9772148600753878,-4.1990651171213749,-0.60961645923282592 | 2.9771990599110714,4.1990550635382533,0.60958597917205148 | Feature - Feature Definition: No Feature Definition; Feature Name: 1; Solid - Surface Area: 1001.73 us survey square foot; Volume: 1197.56 ft³ (us survey); General - Name: 1; Support Name: Pier1; Pier Footing - ItemTypes - Slope: 0; Rotation Angle: 0 deg; Length: 25 us survey foot; Surface Area: 1001.73 us survey square foot; Drill shaft diameter: 0 us survey foot; Association Type: Default; Top Elevation: 1149.53; Associated column: 1; Has Concrete Pad: False; Width: 12 us survey foot; Height: 4 us survey foot; Sloped Extra Top Length: 0 us survey foot; Extra Length: 0 us survey foot; Slope Height: 0 us survey foot; Sloped Top Width: 0 us survey foot; Sloped Top Length: 0 us survey foot; Drill Shaft Height: 0 us survey foot; Volume: 1197.56 ft3; Name: 1; Support Name: Pier1; Footing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Concrete Pad Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Footing - Footing Type: Rectangular Isolated; Bottom Elevation: 1145.53 us survey foot; Assoc. Column ID: 1; Sloped: no; Footing Association: Default; Concrete Pad: no; Top Elevation: 1149.53 us survey foot; Rotation: 0 deg; Height: 4 us survey foot; Slope Depth: 0 us survey foot; Top Width: 0 us survey foot; Top Length: 0 us survey foot; Width: 12 us survey foot; Length: 25 us survey foot; Material - Footing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:51.694Z | Smart Solid | 5333567.9179324359,2184687.1596850394,338.34192024384049 | 0 | 0 | 0 | -2.6089592552700722,-1.3669284555562808,-11.18033293683288 | 2.6089676493997747,1.3669129301096361,11.180329961741664 | Feature - Feature Definition: No Feature Definition; Feature Name: P1; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P1; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167591 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1073.56 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: -9.462 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: -45 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P1; Top X: 17498540 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: -9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1073.56 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498540 us survey foot; Top Y: 7167591 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: -45 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:51.765Z | Smart Solid | 5333566.943530607,2184684.3529438656,338.18852933705864 | 0 | 0 | 0 | -1.9358028760057573,-0.77966919612015806,-11.295374830724761 | 1.9357981072720576,0.77968154940754175,11.295370678027194 | Feature - Feature Definition: No Feature Definition; Feature Name: P2; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P2; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167587 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P2; Top X: 17498538 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498538 us survey foot; Top Y: 7167587 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:51.829Z | Smart Solid | 5333566.5769926338,2184683.2971602743,338.18852933705864 | 0 | 0 | 0 | -1.9358012610924129,-0.77967244597028218,-11.295374830724761 | 1.935799722185402,0.77967829955741763,11.295370678027194 | Feature - Feature Definition: No Feature Definition; Feature Name: P3; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P3; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167584 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P3; Top X: 17498537 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498537 us survey foot; Top Y: 7167584 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:51.898Z | Smart Solid | 5333566.2104546605,2184682.2413766827,338.18852933705864 | 0 | 0 | 0 | -1.9357996461790685,-0.77967569628606759,-11.295374830782798 | 1.9358013370987464,0.77967504924163222,11.295370677969157 | Feature - Feature Definition: No Feature Definition; Feature Name: P4; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P4; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167580 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P4; Top X: 17498536 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498536 us survey foot; Top Y: 7167580 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:51.966Z | Smart Solid | 5333565.8439166872,2184681.185593091,338.18852933705864 | 0 | 0 | 0 | -1.9357980312657241,-0.77967894567053042,-11.295374830782798 | 1.9358029520120907,0.77967179985716939,11.295370677969157 | Feature - Feature Definition: No Feature Definition; Feature Name: P5; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P5; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167577 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P5; Top X: 17498535 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498535 us survey foot; Top Y: 7167577 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.034Z | Smart Solid | 5333565.4773787148,2184680.1298094997,338.18852933705864 | 0 | 0 | 0 | -1.9357964144897346,-0.77968219598631583,-11.295374830840949 | 1.9358045687880803,0.77966854954138398,11.295370677911006 | Feature - Feature Definition: No Feature Definition; Feature Name: P6; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P6; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167573 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P6; Top X: 17498534 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498534 us survey foot; Top Y: 7167573 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.102Z | Smart Solid | 5333564.502976886,2184677.3230683259,338.34192024384049 | 0 | 0 | 0 | -1.396435909616669,-2.5901682910096309,-11.180332936832929 | 1.3964309035792617,2.5901825244737551,11.180329961741618 | Feature - Feature Definition: No Feature Definition; Feature Name: P7; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P7; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167570 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1073.56 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 9.462 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 45 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P7; Top X: 17498532 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1073.56 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498532 us survey foot; Top Y: 7167570 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 45 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.165Z | Smart Solid | 5333564.8554940308,2184688.2499263398,338.18852933705864 | 0 | 0 | 0 | -0.77967767882981842,-1.9358027861880718,-11.295374830782784 | 0.77967306669788172,1.9357981970897429,11.295370677969174 | Feature - Feature Definition: No Feature Definition; Feature Name: P8; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P8; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167592 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: -9.462 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P8; Top X: 17498535 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: -9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498535 us survey foot; Top Y: 7167592 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.230Z | Smart Solid | 5333563.8727101851,2184685.419044958,338.03303530607059 | 0 | 0 | 0 | -0.16399630192447368,-0.16233890029729958,-11.430038100076061 | 0.16397404205054045,0.16234184567524831,11.430007620015374 | Feature - Feature Definition: No Feature Definition; Feature Name: P9; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P9; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167589 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1071.53 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P9; Top X: 17498534 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1071.53 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498534 us survey foot; Top Y: 7167589 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.303Z | Smart Solid | 5333563.5061569717,2184684.3632613663,338.03303530607059 | 0 | 0 | 0 | -0.16397944777984086,-0.16234215107874628,-11.430038100076061 | 0.16399089619517326,0.16233859489380162,11.430007620015374 | Feature - Feature Definition: No Feature Definition; Feature Name: P10; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P10; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167585 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1071.53 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P10; Top X: 17498533 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1071.53 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498533 us survey foot; Top Y: 7167585 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.379Z | Smart Solid | 5333563.1396342395,2184683.307477775,338.03303530607059 | 0 | 0 | 0 | -0.16399307116646233,-0.16234539999754782,-11.430038100076061 | 0.16397727280855179,0.16233534597500007,11.430007620015374 | Feature - Feature Definition: No Feature Definition; Feature Name: P11; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P11; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167582 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1071.53 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P11; Top X: 17498532 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1071.53 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498532 us survey foot; Top Y: 7167582 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.449Z | Smart Solid | 5333562.773081026,2184682.2516789432,338.03303530607059 | 0 | 0 | 0 | -0.16397621609050694,-0.16233340968506094,-11.430038100076061 | 0.16399412788450718,0.16234733628748696,11.430007620015374 | Feature - Feature Definition: No Feature Definition; Feature Name: P12; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P12; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167578 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1071.53 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P12; Top X: 17498531 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1071.53 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498531 us survey foot; Top Y: 7167578 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
