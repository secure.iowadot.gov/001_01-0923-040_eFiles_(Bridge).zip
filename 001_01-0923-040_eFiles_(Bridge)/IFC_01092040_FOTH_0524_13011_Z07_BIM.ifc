Properties of the parts of a building model (IFC4X3_ADD2), part 38 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.082Z | Line | 5333612.0817983728,2184691.1487362492,359.68951416210558 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.091Z | Line | 5333612.0817983728,2184691.1487362501,359.4462578757192 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.101Z | Line | 5333612.0817983728,2184691.1487362506,359.20300158940438 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.110Z | Line | 5333612.0846159803,2184690.9598441483,360.9731477829913 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.121Z | Line | 5333612.0846159803,2184690.9598441487,360.65271765090341 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.129Z | Line | 5333612.0846159803,2184690.9598441496,360.31474487840779 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6342482922482304e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.140Z | Complex Chain | 5333610.8552666409,2184690.7795336558,360.89223606229893 | 0 | 0 | 0 | -0.0054018970431942027,-9.3132257461547852e-10,-0.05526269324070654 | 1.1858093297437491e-09,0.36191163072108762,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.151Z | Complex Chain | 5333610.849865892,2184691.1414453061,360.57180595650505 | 0 | 0 | 0 | -1.3401838486627043e-09,-0.36191163211576716,-0.055262696470151695 | 0.0054018990602134878,0,0.09525007385554464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.160Z | Complex Chain | 5333611.3124167016,2184690.7863527332,360.89223606229893 | 0 | 0 | 0 | -0.0054018970431942027,-9.3132257461547852e-10,-0.05526269324070654 | 9.3132257461547852e-10,0.36191163072108762,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.170Z | Complex Chain | 5333611.3070159527,2184691.1482643834,360.57180595650505 | 0 | 0 | 0 | -1.3401838486627043e-09,-0.36191163165010587,-0.055262696470151695 | 0.0054018990602134878,0,0.09525007385554464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.179Z | Complex Chain | 5333611.9790944457,2184690.7962972294,360.89223606229893 | 0 | 0 | 0 | -0.0054018970431942027,-9.3132257461547852e-10,-0.05526269324070654 | 1.1858093298521694e-09,0.36191163072108762,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.188Z | Complex Chain | 5333611.9736936968,2184691.1582088796,360.57180595650505 | 0 | 0 | 0 | -1.3401838486627043e-09,-0.36191163165010587,-0.055262696470151695 | 0.0054018990602134878,0,0.095250073855544654
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.198Z | Complex Chain | 5333613.1076842919,2184690.8131318358,360.89223606229893 | 0 | 0 | 0 | -0.0054018979745167773,-9.3132257461547852e-10,-0.05526269324070654 | 9.3132257461547852e-10,0.36191163072108762,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.206Z | Complex Chain | 5333613.102283542,2184691.1750434865,360.57180595650505 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163211576716,-0.055262696470151695 | 0.0054018999915360624,0,0.09525007385554464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.215Z | Complex Chain | 5333612.6838668231,2184690.8068099641,360.89223606229893 | 0 | 0 | 0 | -0.0054018970431942027,-9.3132257461547852e-10,-0.05526269324070654 | 9.3132257461547852e-10,0.36191163072108762,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.225Z | Complex Chain | 5333612.6784660742,2184691.1687216144,360.57180595650505 | 0 | 0 | 0 | -1.3401838486627043e-09,-0.36191163211576716,-0.055262696470151695 | 0.0054018990602134878,0,0.09525007385554464
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.235Z | Line | 5333612.5617537312,2184690.8431235468,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,6.0535967350006104e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.244Z | Complex Chain | 5333611.1192829069,2184690.9962519449,360.95727274278414 | 0 | 0 | 0 | 0,0,0 | 2.0283356672152877,0.096938213333487511,2.9103830456733704e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.255Z | Complex Chain | 5333611.1192829069,2184690.9962519454,360.63684261069631 | 0 | 0 | 0 | 0,0,0 | 2.0283356672152877,0.096938213333487511,2.9160673875594512e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.265Z | Line | 5333610.334645221,2184690.7702744151,360.9238550002899 | 0 | 0 | 0 | 0,0,0 | 1.2112540611997247,0.13898987462744117,1.5347723092418164e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.274Z | Line | 5333610.3346452219,2184690.7702744147,360.60342489273637 | 0 | 0 | 0 | 0,0,0 | 1.2112540611997247,0.13898987462744117,1.5347723092418164e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.284Z | Complex Chain | 5333546.9706284925,2184676.3059783205,360.83405461976514 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191162978976504,-0.05526269324070654 | 0.0054018979745167712,1.0338462100301093e-09,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.292Z | Complex Chain | 5333546.9760292424,2184675.9440666703,360.51362451397119 | 0 | 0 | 0 | -0.0054018999915360555,0,-0.055262696470151695 | 9.3132257461547852e-10,0.36191163258142844,0.095250073855544654
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.302Z | Line | 5333544.2377078906,2184676.2270776378,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.310Z | Line | 5333544.5207055463,2184676.231298971,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.320Z | Line | 5333545.0867008585,2184676.2397416383,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.328Z | Line | 5333545.3696985142,2184676.243962972,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.335Z | Line | 5333545.6526961699,2184676.2481843056,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.342Z | Line | 5333545.9356938256,2184676.2524056388,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.350Z | Line | 5333546.2186914813,2184676.2566269725,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.359Z | Line | 5333544.2426327672,2184675.8969146721,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.368Z | Line | 5333544.5256304229,2184675.9011360053,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.375Z | Line | 5333544.8086280786,2184675.905357339,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.385Z | Line | 5333545.0916257352,2184675.9095786726,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.393Z | Line | 5333545.3746233908,2184675.9138000063,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.403Z | Line | 5333545.6576210465,2184675.9180213395,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.412Z | Line | 5333545.9406187022,2184675.9222426731,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.421Z | Line | 5333546.2236163588,2184675.9264640068,360.90694867071886 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.8288036576075228 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.431Z | Line | 5333544.2120502153,2184676.2441593925,360.88154861890331 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307011678814888,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.439Z | Line | 5333544.2120502153,2184676.2441593907,360.56111851130873 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307011678814888,1.893454282253515e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.449Z | Line | 5333544.2120502153,2184676.2441593893,360.2406884037141 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307011678814888,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.458Z | Line | 5333544.2120502153,2184676.2441593874,359.92025829611947 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307011678814888,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.468Z | Line | 5333544.2120975703,2184676.2409847341,359.71705788972866 | 0 | 0 | 0 | 0,0,0 | 2.0317780403420329,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.476Z | Line | 5333544.2120502153,2184676.244159386,359.61545768651825 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307011678814888,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.486Z | Line | 5333544.2120502153,2184676.244159387,359.12894511379005 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307011678814888,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.495Z | Line | 5333544.2120502153,2184676.2441593846,359.37220140013778 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307011678814888,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.504Z | Line | 5333544.2169750901,2184675.9139964203,359.12894511482983 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.511Z | Line | 5333544.2169750901,2184675.913996418,359.37220140117756 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.519Z | Line | 5333544.2169750901,2184675.9139964194,359.61545768755803 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.527Z | Line | 5333544.2169750901,2184675.9139964208,359.92025829715925 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.536Z | Line | 5333544.2169750901,2184675.9139964227,360.24068840475388 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.544Z | Line | 5333544.2169750901,2184675.9139964241,360.56111851234851 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.555Z | Line | 5333544.2169750901,2184675.9139964259,360.88154861994315 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.562Z | Line | 5333545.2787336847,2184676.2600705735,360.89742365084265 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.573Z | Line | 5333545.2787336847,2184676.2600705726,360.57699354309142 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.582Z | Line | 5333545.2787336847,2184676.2600705712,360.25656343572922 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.593Z | Line | 5333545.2787336847,2184676.2600705703,359.93613332811623 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.603Z | Line | 5333545.2787336847,2184676.2600705693,359.6313327185527 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.611Z | Line | 5333545.2787336847,2184676.2600705684,359.38807643194804 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.622Z | Line | 5333545.2787336847,2184676.260070568,359.14482014588896 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.632Z | Line | 5333545.2834199062,2184675.9459068435,360.89742365183986 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.642Z | Line | 5333545.2834199062,2184675.9459068426,360.57699354428632 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.653Z | Line | 5333545.2836585594,2184675.9299076046,360.25656343641839 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.662Z | Line | 5333545.2836585594,2184675.9299076037,359.93613332912901 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.672Z | Line | 5333545.2836585594,2184675.9299076027,359.63133271957173 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.683Z | Line | 5333545.2836585594,2184675.9299076018,359.38807643318535 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.691Z | Line | 5333545.2836585594,2184675.9299076013,359.14482014687059 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.702Z | Line | 5333545.2808409519,2184676.1187997037,360.91496634045745 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.710Z | Line | 5333545.2808409519,2184676.1187997032,360.59453620836962 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.720Z | Line | 5333545.2808409519,2184676.1187997023,360.25656343587394 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.728Z | Complex Chain | 5333546.5101902913,2184676.2991101961,360.83405461976514 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163025542633,-0.05526269324070654 | 0.0054018970431941966,9.3132257461547852e-10,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.738Z | Complex Chain | 5333546.5155910403,2184675.9371985458,360.51362451397119 | 0 | 0 | 0 | -0.00540189906021348,0,-0.055262696470151695 | 1.3401838321828313e-09,0.36191163211576716,0.09525007385554464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.748Z | Complex Chain | 5333546.0530402306,2184676.2922911188,360.83405461976514 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163025542633,-0.05526269324070654 | 0.0054018970431941966,9.3132257461547852e-10,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.756Z | Complex Chain | 5333546.0584409796,2184675.930379468,360.51362451397119 | 0 | 0 | 0 | -0.0054018990602134808,0,-0.055262696470151695 | 1.3401838321828313e-09,0.36191163258142844,0.09525007385554464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.767Z | Complex Chain | 5333545.3863624865,2184676.2823466226,360.83405461976514 | 0 | 0 | 0 | -1.1858093255153607e-09,-0.36191163025542633,-0.05526269324070654 | 0.0054018970431941966,9.3132257461547852e-10,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.775Z | Complex Chain | 5333545.3917632354,2184675.9204349723,360.51362451397119 | 0 | 0 | 0 | -0.0054018990602134817,0,-0.055262696470151695 | 1.3401838321828313e-09,0.36191163211576716,0.095250073855544654
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.786Z | Complex Chain | 5333544.2577726403,2184676.2655120157,360.83405461976514 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191162978976504,-0.05526269324070654 | 0.0054018979745167712,1.0338462308467911e-09,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.794Z | Complex Chain | 5333544.2631733902,2184675.9036003654,360.51362451397119 | 0 | 0 | 0 | -0.0054018999915360555,0,-0.055262696470151695 | 9.3132257461547852e-10,0.36191163258142844,0.09525007385554464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.807Z | Complex Chain | 5333544.6815901091,2184676.2718338878,360.83405461976514 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163025542633,-0.05526269324070654 | 0.0054018970431941966,9.3132257461547852e-10,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.816Z | Complex Chain | 5333544.6869908581,2184675.9099222375,360.51362451397119 | 0 | 0 | 0 | -0.0054018990602134808,0,-0.055262696470151695 | 1.3401838321828313e-09,0.3619116321157671,0.09525007385554464
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.825Z | Line | 5333544.803703201,2184676.2355203051,360.90694866991424 | 0 | 0 | 0 | 0,-6.0535967350006104e-09,-1.828803657607466 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.835Z | Complex Chain | 5333546.2461740253,2184676.082391907,360.89909130025029 | 0 | 0 | 0 | -2.0283356672152877,-0.096938213333487511,0 | 0,0,2.9103830456733704e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.845Z | Complex Chain | 5333546.2461740253,2184676.0823919065,360.57866116816245 | 0 | 0 | 0 | -2.0283356672152877,-0.096938213333487511,0 | 0,0,2.9160673875594512e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.852Z | Line | 5333547.0308117112,2184676.3083694368,360.86567355775605 | 0 | 0 | 0 | -1.2112540611997247,-0.13898987462744117,0 | 0,0,1.5347723092418164e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.860Z | Line | 5333547.0308117103,2184676.3083694372,360.54524345020258 | 0 | 0 | 0 | -1.2112540611997247,-0.13898987462744117,0 | 0,0,1.5290879673557356e-11
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.885Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333548.83366316,2184689.8005446303,359.04882250209522 | 5333550.9742280031,2184690.314913312,360.98246760812543
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.894Z | Extended Element | 5333548.8307260126,2184690.2830471387,359.04882696476295 | 0.854589 | -0.0870403 | 90 | -0.0071970894587944922,-1.0933393168377492e-05,-0.031818823845347705 | 2.1437363762689632,1.9368950494577382,0.51441882204942613
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.921Z | Extended Element | 5333551.6484435285,2184689.9833238078,360.8002695172197 | -179.145 | -8.19083e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.946Z | Extended Element | 5333551.1880053272,2184689.9764556834,360.80026951724994 | -179.145 | -0.0000010171 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.972Z | Extended Element | 5333550.7308552656,2184689.9696366056,360.8002695171869 | -179.145 | -8.17531e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.999Z | Extended Element | 5333550.0641775234,2184689.9596921098,360.80026951734345 | -179.145 | -0.00000100988 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.024Z | Extended Element | 5333549.3594051441,2184689.9491793746,360.80026951691843 | -179.145 | -4.33044e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.051Z | Extended Element | 5333548.9355876781,2184689.9428575034,360.80026951710852 | -179.145 | -0.00000159251 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.076Z | Extended Element | 5333548.9323988166,2184690.1564246458,360.47983940849497 | 0.855133 | -4.38795e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.103Z | Extended Element | 5333549.3562162844,2184690.1627465161,360.47983940903561 | 0.855132 | -6.23781e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.128Z | Extended Element | 5333550.0609886609,2184690.1732592513,360.47983940877174 | 0.855132 | -6.29587e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.156Z | Extended Element | 5333550.727666405,2184690.1832037475,360.47983940863969 | 0.855133 | -0.0000010084 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.182Z | Extended Element | 5333551.1848164648,2184690.1900228248,360.47983940869653 | 0.855133 | -4.37316e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.207Z | Extended Element | 5333551.6452546669,2184690.1968909493,360.47983940902674 | 0.855132 | -6.23781e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.230Z | Extended Element | 5333549.9522539154,2184690.2251554555,360.9189012423293 | -89.1455 | -90.0098 | -0.0000766088 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.254Z | Extended Element | 5333549.9543611826,2184690.0838845856,360.93644393149935 | -89.1455 | -90.0098 | -0.0000766162 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.279Z | Extended Element | 5333549.9569401368,2184689.9109917255,360.91890124233726 | -89.1455 | -90.0098 | -0.0000766088 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.306Z | Extended Element | 5333549.9522539154,2184690.2251554555,360.59847113457806 | -89.1455 | -90.0098 | -0.000076688 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.330Z | Extended Element | 5333549.9543611836,2184690.0838845856,360.61601379941152 | -89.1455 | -90.0098 | -0.0000766621 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.360Z | Extended Element | 5333549.9522539154,2184690.2251554555,360.27804102721592 | -89.1455 | -90.0098 | -0.0000767451 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.386Z | Extended Element | 5333549.9543611826,2184690.0838845866,360.27804102691567 | -89.1455 | -90.0098 | -0.0000767562 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.411Z | Extended Element | 5333549.9522539154,2184690.225155456,359.95761091960304 | -89.1455 | -90.0098 | -0.0000768134 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.438Z | Extended Element | 5333549.9522539154,2184690.2251554555,359.6528103100394 | -89.1455 | -90.0098 | -0.0000768785 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.464Z | Extended Element | 5333549.9571787901,2184689.8949924889,359.95761091957581 | -89.1455 | -90.0098 | -0.0000768134 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.490Z | Extended Element | 5333549.9522539154,2184690.2251554555,359.40955402343479 | -89.1455 | -90.0098 | -0.0000769306 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.514Z | Extended Element | 5333549.9571787901,2184689.8949924894,359.65281031001871 | -89.1455 | -90.0098 | -0.0000768785 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.537Z | Extended Element | 5333549.9522539154,2184690.225155456,359.16629773737583 | -89.1455 | -90.0098 | -0.0000769827 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.560Z | Extended Element | 5333549.9571787901,2184689.8949924894,359.40955402363238 | -89.1455 | -90.0098 | -0.0000769306 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.584Z | Extended Element | 5333549.9571787901,2184689.8949924894,359.16629773731751 | -89.1455 | -90.0098 | -0.0000769938 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.609Z | Extended Element | 5333549.9571787901,2184689.8949924889,360.27804102686531 | -89.1455 | -90.0098 | -0.0000767562 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.636Z | Extended Element | 5333549.9569401368,2184689.9109917255,360.59847113478372 | -89.1455 | -90.0098 | -0.0000766658 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.661Z | Extended Element | 5333551.709965243,2184689.8957985635,360.88715115726637 | 85.1632 | 90.0079 | 7.3664e-07 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.688Z | Extended Element | 5333551.709965243,2184689.8957985635,360.56672104971295 | 85.1632 | 90.0079 | 7.17368e-07 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.714Z | Extended Element | 5333550.9189365618,2184690.098272671,360.92056889974918 | 1.28027 | -90 | -89.5743 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.739Z | Extended Element | 5333550.9189365609,2184690.098272671,360.60013876766141 | 1.28027 | -90 | -89.5743 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.767Z | Extended Element | 5333548.8855704442,2184690.2092442731,360.90302621038978 | -89.1454 | -90.0098 | 0.00000805992 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.794Z | Extended Element | 5333548.885570446,2184690.2092442731,360.58259610279543 | -89.1454 | -90.0098 | 0.00000806708 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.824Z | Extended Element | 5333548.8855704442,2184690.2092442731,360.2621659952008 | -89.1454 | -90.0098 | 0.00000807426 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.852Z | Extended Element | 5333548.8855704451,2184690.2092442713,359.94173588760617 | -89.1454 | -90.0098 | 0.00000808144 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.880Z | Extended Element | 5333548.8855704451,2184690.2092442713,359.6369352780049 | -89.1454 | -90.0098 | 0.0000080979 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.906Z | Extended Element | 5333548.8855704442,2184690.2092442708,359.39367899162443 | -89.1454 | -90.0098 | 0.00000810338 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.930Z | Extended Element | 5333548.8855704451,2184690.2092442736,359.15042270527675 | -89.1454 | -90.0098 | 0.00000809925 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.954Z | Extended Element | 5333548.8904953208,2184689.8790813079,359.1504227052767 | -89.1454 | -90.0098 | 0.00000809925 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:03.980Z | Extended Element | 5333548.8904953217,2184689.8790813051,359.39367899162454 | -89.1454 | -90.0098 | 0.00000810338 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.007Z | Extended Element | 5333548.8904953199,2184689.8790813056,359.63693527800501 | -89.1454 | -90.0098 | 0.0000080979 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.033Z | Extended Element | 5333548.8904953208,2184689.8790813065,359.94173588760623 | -89.1454 | -90.0098 | 0.00000808144 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.056Z | Extended Element | 5333548.8904953217,2184689.879081307,360.26216599520092 | -89.1454 | -90.0098 | 0.00000807426 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.083Z | Extended Element | 5333548.8904953208,2184689.8790813074,360.58259610279549 | -89.1454 | -90.0098 | 0.00000806708 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.109Z | Extended Element | 5333548.8904953208,2184689.8790813079,360.90302621039001 | -89.1454 | -90.0098 | 0.00000805992 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.137Z | Extended Element | 5333548.9161529979,2184689.8619995536,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.164Z | Extended Element | 5333549.1991506536,2184689.8662208868,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.192Z | Extended Element | 5333549.4821483111,2184689.8704422209,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.219Z | Extended Element | 5333549.7651459677,2184689.8746635551,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.245Z | Extended Element | 5333550.0481436215,2184689.8788848883,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.272Z | Extended Element | 5333550.3311412772,2184689.883106221,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.297Z | Extended Element | 5333550.6141389329,2184689.8873275542,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.325Z | Extended Element | 5333550.8971365904,2184689.8915488883,360.92842626111076 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.351Z | Extended Element | 5333548.9112281222,2184690.1921625189,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.375Z | Extended Element | 5333549.1942257788,2184690.1963838525,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.396Z | Extended Element | 5333549.4772234336,2184690.2006051866,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.422Z | Extended Element | 5333549.7602210892,2184690.2048265198,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.443Z | Extended Element | 5333550.0432187459,2184690.2090478535,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.469Z | Extended Element | 5333550.3262164015,2184690.2132691876,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.494Z | Extended Element | 5333550.6092140572,2184690.2174905203,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.522Z | Extended Element | 5333550.8922117138,2184690.221711854,360.92842626134598 | 112.275 | 0 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.542Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333611.0635418547,2184690.7276084176,359.08431933567653 | 5333613.2065210128,2184691.2443911145,361.0203784691505
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.561Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333606.3912282763,2184676.7625214914,359.0997617526948 | 5333608.5330007812,2184677.2780985534,361.03582088550667
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.581Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333544.1601429293,2184675.8354597432,359.02734490259553 | 5333546.3007077724,2184676.3498284249,360.96099000862574
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.594Z | Extended Element | 5333611.0635418547,2184690.7276084176,359.08431933567653 | 0 | 0 | 0 | 7.893321551932786e-10,1.099905722057315e-10,8.4376949871511897e-15 | 2.1429791590615332,0.51678269668883525,1.9360591334739641
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.621Z | Extended Element | 5333610.3905336354,2184691.0604049265,360.83697336880556 | 0.855133 | -0.00000100555 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.647Z | Extended Element | 5333610.8509718375,2184691.067273051,360.83697336874019 | 0.855133 | -0.00000120499 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.671Z | Extended Element | 5333611.3081218982,2184691.0740921283,360.83697336953509 | 0.855133 | -0.00000119054 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.697Z | Extended Element | 5333611.9747996423,2184691.0840366245,360.8369733690198 | 0.855132 | -6.18031e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.722Z | Extended Element | 5333612.6795720179,2184691.0945493588,360.83697336909364 | 0.855133 | -0.0000010142 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.750Z | Extended Element | 5333613.1033894895,2184691.1008712314,360.83697336935819 | 0.855134 | -0.00000140172 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.772Z | Extended Element | 5333613.1065783482,2184690.8873040904,360.51654325989045 | -179.145 | -6.26684e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.795Z | Extended Element | 5333612.6827608803,2184690.8809822188,360.51654326007309 | -179.145 | -0.00000100549 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.824Z | Extended Element | 5333611.9779885039,2184690.870469484,360.51654326038192 | -179.145 | -8.24834e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.849Z | Extended Element | 5333611.3113107579,2184690.8605249883,360.51654325987403 | -179.145 | -8.24834e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.872Z | Extended Element | 5333610.8541607,2184690.85370591,360.51654325997754 | -179.145 | -0.00000100697 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.896Z | Extended Element | 5333610.3937224979,2184690.846837786,360.5165432598485 | -179.145 | -6.26684e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.911Z | Extended Element | 5333606.3912282763,2184676.7625214914,359.09976175269475 | 0 | 0 | 0 | 2.4584201341326661e-10,2.0357610042154306e-10,3.5416114485542494e-14 | 2.1417725049430105,0.51557706193331843,1.9360591328119294
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.937Z | Extended Element | 5333605.7170134,2184677.0953189703,360.85241577465797 | 0.855134 | -8.1766e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.961Z | Extended Element | 5333606.1774516003,2184677.1021870947,360.85241577639505 | 0.855133 | -4.28718e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:04.987Z | Extended Element | 5333606.634601661,2184677.1090061725,360.85241577798013 | 0.855134 | -8.26313e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.011Z | Extended Element | 5333607.301279407,2184677.1189506692,360.85241578092308 | 0.855134 | -8.16236e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.038Z | Extended Element | 5333608.0060517834,2184677.129463403,360.85241578393362 | 0.855133 | -4.24391e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.063Z | Extended Element | 5333608.4298692513,2184677.1357852751,360.8524157856038 | 0.855133 | -0.00000100122 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.089Z | Extended Element | 5333608.4330581129,2184676.9222181342,360.5319856769421 | -179.145 | -0.00000120784 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.113Z | Extended Element | 5333608.0092406459,2184676.915896262,360.53198567525214 | -179.145 | -0.00000120927 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.140Z | Extended Element | 5333607.3044682676,2184676.9053835277,360.5319856721477 | -179.145 | -0.00000121359 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.166Z | Extended Element | 5333606.6377905225,2184676.895439032,360.53198566974919 | -179.145 | -0.0000010228 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.186Z | Extended Element | 5333606.1806404609,2184676.8886199538,360.53198566780617 | -179.145 | -0.00000100692 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.210Z | Extended Element | 5333605.7202022616,2184676.8817518293,360.53198566605965 | -179.145 | -0.00000159388 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.223Z | Extended Element | 5333544.1572057838,2184676.3179622511,359.02734936526326 | 0.854589 | -0.0870403 | 90 | -0.0071970921082600281,-1.0933395385270828e-05,-0.031818823369282656 | 2.1437363736194976,1.9368950494555213,0.51441882252549109
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.248Z | Extended Element | 5333544.2620674446,2184675.977772621,360.77879192643769 | -179.145 | -0.00000101135 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.275Z | Extended Element | 5333544.6858849144,2184675.9840944926,360.77879192664267 | -179.145 | -0.00000100412 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.299Z | Extended Element | 5333545.3906572927,2184675.9946072279,360.77879192674573 | -179.145 | -8.14628e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.326Z | Extended Element | 5333546.0573350368,2184676.0045517241,360.77879192667081 | -179.145 | -0.00000120647 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.352Z | Extended Element | 5333546.5144850975,2184676.0113708009,360.77879192641376 | -179.145 | -0.00000100703 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.376Z | Extended Element | 5333546.9749232978,2184676.0182389268,360.7787919263734 | -179.145 | -6.26739e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.403Z | Extended Element | 5333546.9717344381,2184676.2318060668,360.45836181763832 | 0.855133 | -4.43121e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.428Z | Extended Element | 5333546.511296235,2184676.2249379414,360.4583618174579 | 0.855134 | -8.2916e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.454Z | Extended Element | 5333546.0541461753,2184676.2181188641,360.4583618175493 | 0.855134 | -8.30584e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.480Z | Extended Element | 5333545.3874684302,2184676.2081743674,360.45836181761314 | 0.855133 | -0.00000101995 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.506Z | Extended Element | 5333544.6826960538,2184676.1976616336,360.45836181787587 | 0.855134 | -8.26258e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.531Z | Extended Element | 5333544.2588785859,2184676.1913397624,360.45836181753168 | 0.855133 | -4.32989e-07 | 45 | -0.010863774114168067,-0.16889844174005858,-0.0098995940656771246 | 0.010863780043592839,0.14647826791360796,0.2984203645975233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.558Z | Extended Element | 5333612.082037027,2184691.1327370089,360.95560509437371 | 90.8546 | 90.0098 | 0.0000143037 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.585Z | Extended Element | 5333612.0846159812,2184690.9598441483,360.97314778299119 | 90.8546 | 90.0098 | 0.000014303 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.610Z | Extended Element | 5333612.0820370261,2184691.1327370093,360.63517498682018 | 90.8546 | 90.0098 | 0.0000143164 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.636Z | Extended Element | 5333612.0846159812,2184690.9598441487,360.65271765090347 | 90.8546 | 90.0098 | 0.0000143157 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.662Z | Extended Element | 5333612.0817983737,2184691.1487362473,360.31474487895224 | 90.8546 | 90.0098 | 0.0000143291 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.688Z | Extended Element | 5333612.0867232475,2184690.8185732793,360.63517498562533 | 90.8546 | 90.0098 | 0.0000143275 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.714Z | Extended Element | 5333612.0846159812,2184690.9598441496,360.31474487840785 | 90.8546 | 90.0098 | 0.0000143291 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.735Z | Extended Element | 5333612.0817983747,2184691.1487362487,359.99431477166291 | 90.8546 | 90.0098 | 0.0000143419 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.759Z | Extended Element | 5333612.0867232475,2184690.8185732802,360.31474487826301 | 90.8546 | 90.0098 | 0.0000143291 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.785Z | Extended Element | 5333612.0817983737,2184691.1487362492,359.68951416210552 | 90.8546 | 90.0098 | 0.000014354 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.810Z | Extended Element | 5333612.0867232475,2184690.8185732821,359.99431477065002 | 90.8546 | 90.0098 | 0.0000143419 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.837Z | Extended Element | 5333612.0817983747,2184691.1487362501,359.44625787571931 | 90.8546 | 90.0098 | 0.0000143749 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.864Z | Extended Element | 5333612.0867232475,2184690.8185732826,359.68951416108655 | 90.8546 | 90.0098 | 0.000014354 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.892Z | Extended Element | 5333612.0817983747,2184691.1487362511,359.20300158940444 | 90.8546 | 90.0098 | 0.0000143735 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.918Z | Extended Element | 5333612.0867232485,2184690.818573284,359.44625787448183 | 90.8546 | 90.0098 | 0.0000143526 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.947Z | Extended Element | 5333612.0867232485,2184690.8185732844,359.20300158842281 | 90.8546 | 90.0098 | 0.0000143735 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.972Z | Extended Element | 5333610.3346452219,2184690.7702744151,360.92385500029002 | -83.454 | -90.0132 | -0.00000311432 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:05.997Z | Extended Element | 5333610.3346452219,2184690.7702744147,360.60342489273631 | -83.454 | -90.0132 | -0.00000312894 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.022Z | Extended Element | 5333612.0867232475,2184690.8185732784,360.95560509337656 | 90.8546 | 90.0098 | 0.0000143037 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.048Z | Extended Element | 5333607.4085167889,2184677.1676510531,360.97104750668757 | 90.8532 | 90.0098 | 0.00135133 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.075Z | Extended Element | 5333607.4110957431,2184676.9947581929,360.98859019557739 | 90.8532 | 90.0098 | 0.00135127 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
