Properties of the parts of a building model (IFC4X3_ADD2), part 31 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.054Z | Line | 5333562.6107446067,2184682.0751650417,360.86960355856115 | 0 | 0 | 0 | 0,0,0 | 0.2031778022646904,0.0030306996777653694,0.0010915133220237294
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.065Z | Line | 5333561.8578203348,2184679.6102362028,360.81825912673827 | 0 | 0 | 0 | 0,0,0 | 0.85451317206025124,2.4664441882632673,0.05189018848386695
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.093Z | Extended Element | 5333561.8716948228,2184680.5053742402,360.97001471677157 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.102Z | Extended Element | 5333562.4761781069,2184680.5431726966,360.97465909940342 | 70.8964 | 0.0134784 | 180 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.114Z | Extended Element | 5333562.0246074973,2184680.9467373341,360.97930031673764 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.122Z | Extended Element | 5333562.1010638345,2184681.1674188804,360.98394311672041 | 70.8964 | -179.987 | 0.000161926 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.132Z | Extended Element | 5333562.1775201717,2184681.3881004271,360.9885859167037 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.167Z | Extended Element | 5333562.7268441096,2184682.9669398577,361.00602472303359 | 70.8964 | -179.987 | 0.000161926 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.178Z | Extended Element | 5333562.8030395294,2184683.1864163768,361.0062773732962 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.188Z | Extended Element | 5333562.8792349529,2184683.4058928965,361.00653002355892 | 70.8964 | -179.987 | 0.000161926 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.197Z | Extended Element | 5333562.9554303763,2184683.625369417,361.00678267382159 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.206Z | Extended Element | 5333563.031625797,2184683.8448459357,361.00703532408397 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.240Z | Extended Element | 5333561.6775142103,2184677.7984671518,360.07482795874569 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.253Z | Extended Element | 5333561.7535021538,2184678.0168954246,360.07945156002762 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.264Z | Extended Element | 5333561.8294900991,2184678.2353236973,360.08407516130922 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.276Z | Extended Element | 5333561.9054780472,2184678.4537519692,360.08869876259126 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.285Z | Extended Element | 5333561.9814659888,2184678.6721802414,360.09332236387291 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.311Z | Extended Element | 5333562.5310999872,2184680.2604009723,360.12673702592218 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.320Z | Extended Element | 5333562.6075563263,2184680.4810825186,360.13137982590513 | 70.8964 | 0.0134784 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.330Z | Extended Element | 5333562.6840126626,2184680.7017640648,360.13602262588802 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.341Z | Extended Element | 5333562.7604689999,2184680.9224456111,360.14066542587068 | 70.8964 | 0.0134784 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.352Z | Extended Element | 5333562.836925338,2184681.1431271583,360.14530822585374 | 70.8964 | 0.0134786 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.380Z | Extended Element | 5333563.3862387007,2184682.7219669465,360.16304528935302 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.392Z | Extended Element | 5333563.4624341223,2184682.9414434666,360.1632979396158 | 70.8964 | 0.0134786 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.402Z | Extended Element | 5333563.5386295477,2184683.1609199862,360.16355058987864 | 70.8964 | 0.0134786 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.411Z | Extended Element | 5333563.6148249665,2184683.3803965054,360.16380324014114 | 70.8964 | 0.0134786 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.421Z | Extended Element | 5333563.69102039,2184683.5998730264,360.1640558904042 | 70.8964 | 0.0134786 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.453Z | Extended Element | 5333560.8233089261,2184676.6189554464,360.91951854349531 | -89.1454 | -4.91727e-08 | -179.924 | -0.011397426255988498,-0.40985828498138588,-0.011397646929822057 | 0.011397386263543823,0.15586898078705913,1.0115241239008275
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.482Z | Extended Element | 5333560.6356384661,2184676.9956115368,360.52909612444603 | -179.145 | 89.9236 | 0.000593151 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.518Z | Extended Element | 5333560.6360355159,2184676.9956174549,360.22429557365837 | -179.145 | 89.9236 | 0.000593177 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.549Z | Extended Element | 5333560.7185056712,2184677.5727247852,359.96919153599532 | -67.8603 | 88.4786 | 48.7249 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.581Z | Extended Element | 5333560.6164045259,2184677.2786271409,360.26778052053646 | -67.8604 | 88.4786 | 48.725 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.608Z | Extended Element | 5333560.6164222546,2184677.2785598873,360.52178103656746 | -67.8605 | 88.4786 | 48.7251 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.633Z | Extended Element | 5333561.4853299642,2184677.3030955726,360.52185242576894 | -67.8605 | 88.4786 | 48.7251 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.662Z | Extended Element | 5333561.4853122355,2184677.3031628286,360.26785190978478 | -67.8604 | 88.4786 | 48.725 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.690Z | Extended Element | 5333561.0031621894,2184677.1535109687,360.76625616112403 | -67.8602 | 88.4751 | 48.6883 | -0.0079374999974042067,3.7728185430087052e-10,-0.0079375001041821994 | 0.0079375000088620466,2.6016617249447331,0.0079374998958563342
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.716Z | Extended Element | 5333560.6797553524,2184676.6333823679,360.07637090228337 | -89.1454 | -8.86735e-07 | -89.924 | -0.011397387069976665,-1.830045625009489e-08,-0.011397655768444828 | 0.011397385490960733,0.16856029222363758,0.55432320282081604
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.743Z | Extended Element | 5333562.3379291808,2184679.7589603849,360.57382170449597 | -67.8607 | 88.4815 | 48.7253 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.767Z | Extended Element | 5333562.3379154056,2184679.7590276976,360.31982119152093 | -67.8606 | 88.4815 | 48.7252 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.795Z | Extended Element | 5333561.8578203358,2184679.6102362033,360.81825912675777 | -67.8612 | 88.4855 | 48.7622 | -0.0079375000010814389,2.2310900308802227e-10,-0.0079375000714412437 | 0.0079374999993870494,2.6107915065135474,0.0079374999285617576
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.822Z | Extended Element | 5333561.471004609,2184679.7401445573,360.57381610248558 | -67.8607 | 88.4815 | 48.7253 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.855Z | Extended Element | 5333561.4709908329,2184679.7402118701,360.31981558946291 | -67.8606 | 88.4815 | 48.7252 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.884Z | Extended Element | 5333561.5740068397,2184680.0376445865,360.01508901822058 | -67.8605 | 88.4815 | 48.7251 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.912Z | Extended Element | 5333563.1927265134,2184682.220504486,360.62601337745474 | -70.2783 | 89.9195 | 51.133 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.936Z | Extended Element | 5333563.1928009111,2184682.2208189014,360.37201303975229 | -70.2765 | 89.9195 | 51.1311 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.960Z | Extended Element | 5333563.2953659296,2184682.5162527105,360.06755440913736 | -70.2742 | 89.9195 | 51.1288 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.986Z | Extended Element | 5333562.3255666103,2184682.2016872293,360.62568292179873 | -70.2783 | 89.9195 | 51.1329 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.014Z | Extended Element | 5333562.3256410072,2184682.2020016452,360.37168258409667 | -70.2765 | 89.9195 | 51.1311 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.040Z | Extended Element | 5333562.4282049248,2184682.4974322808,360.06722394980869 | -70.2742 | 89.9195 | 51.1288 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.067Z | Extended Element | 5333564.0470976075,2184684.6821297593,360.62861104414839 | -67.5742 | 91.3578 | 48.4368 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.093Z | Extended Element | 5333564.0470881416,2184684.6821971359,360.3746105341375 | -67.5743 | 91.3578 | 48.4369 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.116Z | Extended Element | 5333564.1495376453,2184684.9772982192,360.0642717799189 | -67.5745 | 91.3578 | 48.437 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.145Z | Extended Element | 5333563.1801709747,2184684.6633139155,360.6285410789892 | -67.5742 | 91.3578 | 48.4368 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.170Z | Extended Element | 5333563.1801615087,2184684.6633812925,360.37454056893205 | -67.5743 | 91.3578 | 48.4369 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.199Z | Extended Element | 5333563.282615087,2184684.9584941026,360.06420159461976 | -67.5745 | 91.3578 | 48.437 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.228Z | Extended Element | 5333565.6622887356,2184689.3339946149,360.53586317641719 | 112.425 | -91.3612 | -48.4372 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.255Z | Extended Element | 5333565.6604838185,2184689.3288763943,360.28191080846892 | 112.425 | -91.3612 | -48.4373 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.283Z | Extended Element | 5333565.0042535774,2184687.4393918831,360.01872301980728 | -67.5748 | 91.3611 | 48.4374 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.313Z | Extended Element | 5333564.7951191375,2184689.3152286713,360.54125440275152 | 112.425 | -91.3612 | -48.4372 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.346Z | Extended Element | 5333564.7933142176,2184689.3101104521,360.28730203476755 | 112.425 | -91.3612 | -48.4373 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.377Z | Extended Element | 5333564.1370647037,2184687.4205702902,360.02411423226414 | -67.5748 | 91.3611 | 48.4374 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.407Z | Extended Element | 5333565.2002597023,2184689.9921761169,360.93474651064417 | -89.1454 | -7.6487e-08 | -179.924 | -0.011397426255988498,-0.40985828498138588,-0.011397646929822057 | 0.011397386263543823,0.15586898078705913,1.0115241239008275
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.437Z | Extended Element | 5333565.0572018279,2184689.9733715635,360.09159576127848 | -89.1454 | -5.44219e-07 | -89.924 | -0.011397387069976665,-1.830045625009489e-08,-0.011397655768444828 | 0.011397385490960733,0.16856029222363758,0.55432320282081604
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.469Z | Extended Element | 5333565.0242748037,2184689.6100955759,360.23954402101322 | 0.854548 | -89.9236 | 0.000510183 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.500Z | Extended Element | 5333565.0236408301,2184689.6100861169,360.54434444036059 | 0.854548 | -89.9236 | 0.000510163 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.527Z | Extended Element | 5333561.0088447398,2184676.7725525876,359.96312280315163 | 0.854588 | -86.6957 | -0.00000126929 | -0.0099494431005378095,-4.2542286690947627e-11,-0.0099494396843274671 | 0.0099494390054477057,3.2036025226294713,0.91217912436103543
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.554Z | Extended Element | 5333562.7162787504,2184682.4508177154,360.06703286290173 | 0.85459 | -86.7363 | -180 | -0.0099659487693956224,-5.7056675646727105e-11,-0.0099659455734878652 | 0.0099659446914429541,3.1966386282374475,0.92169951262588068
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.587Z | Extended Element | 5333562.7083882289,2184681.7025430677,360.06703286337108 | 0.854589 | -89.8206 | 8.38726e-09 | -0.0099641120669230736,1.4478472538955843e-10,-0.0099641106026897627 | 0.00996411206267739,3.1966386251019334,0.92022335831423263
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.617Z | Extended Element | 5333563.5629738923,2184684.1641277792,360.06988285112385 | 0.854589 | -92.906 | 3.53088e-08 | -0.0099655642363339868,-8.3801042346494615e-11,-0.0099655652335661343 | 0.0099655643142615505,3.1966386856398188,0.92139238988785832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.646Z | Extended Element | 5333565.2704079067,2184689.8423929112,359.97735527062417 | -179.145 | -87.0561 | -3.95421e-08 | -0.0099490548572008525,-1.8680592185062096e-10,-0.0099490547501268969 | 0.0099490548957463405,3.2036024659208731,0.91186905442410993
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.689Z | Extended Element | 5333591.6534361942,2184677.0000275779,359.84711604795319 | 0 | 0 | 0 | -1.0809664274802344e-10,1.3199930037899321e-10,7.3274719625260332e-15 | 5.1447553434351478,13.542285305293579,1.1056485682661299
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.721Z | Extended Element | 5333592.1038297191,2184678.5073321215,360.95658357214182 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.736Z | Extended Element | 5333592.1648047036,2184678.6829670439,360.96001437652882 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.748Z | Extended Element | 5333592.2257796852,2184678.8586019659,360.96344518091604 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.758Z | Extended Element | 5333592.2867546678,2184679.0342368875,360.96687598530326 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.774Z | Extended Element | 5333592.3477296503,2184679.2098718076,360.97030678969043 | 70.8964 | -179.987 | 0.00016216 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.787Z | Extended Element | 5333592.408704632,2184679.3855067282,360.97373759407748 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.818Z | Extended Element | 5333592.9584156023,2184680.9689174709,361.00463107485109 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.829Z | Extended Element | 5333593.0346341822,2184681.188460697,361.00890956448461 | 70.8964 | -179.987 | 0.000162641 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.838Z | Extended Element | 5333593.110852764,2184681.4080039235,361.01318805411853 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.848Z | Extended Element | 5333593.7150982935,2184681.4446640578,361.0174681264005 | 70.8964 | 0.0134783 | 180 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.858Z | Extended Element | 5333593.2632899256,2184681.8470903751,361.02174503338586 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.882Z | Extended Element | 5333593.8130482528,2184683.4306375408,361.03667571723111 | 70.8964 | -179.987 | 0.00016216 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.893Z | Extended Element | 5333593.889243504,2184683.650113571,361.03657904448977 | 70.8964 | -179.987 | 0.000161803 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.903Z | Extended Element | 5333593.9654387571,2184683.8695896026,361.03648237174872 | 70.8964 | -179.987 | 0.00016216 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.914Z | Extended Element | 5333594.0416340102,2184684.0890656332,361.03638569900733 | 70.8964 | -179.987 | 0.00016216 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.924Z | Extended Element | 5333594.1178292632,2184684.3085416639,361.03628902626633 | 70.8964 | -179.987 | 0.00016216 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.951Z | Extended Element | 5333594.6675825724,2184685.8920743722,361.01966456282548 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.963Z | Extended Element | 5333594.7285591476,2184686.067713879,361.01608690258212 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.972Z | Extended Element | 5333594.7895357208,2184686.2433533864,361.0125092423379 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.983Z | Extended Element | 5333594.8505122941,2184686.418992891,361.00893158209408 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:36.994Z | Extended Element | 5333594.9114888711,2184686.5946323988,361.0053539218506 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.005Z | Extended Element | 5333594.9724654444,2184686.7702719043,361.00177626160649 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.031Z | Extended Element | 5333596.0501949582,2184688.1707753376,360.96948991294414 | 70.8964 | 0.0134783 | 180 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.041Z | Extended Element | 5333596.1111716488,2184688.3464151784,360.96590432811672 | 70.8964 | 0.0134784 | 180 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.052Z | Extended Element | 5333595.644121388,2184688.7049381132,360.96231716064142 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.063Z | Extended Element | 5333595.7050980804,2184688.8805779554,360.95873157581394 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.073Z | Extended Element | 5333595.7660747711,2184689.056217798,360.95514599098675 | 70.8964 | -179.987 | 0.000162641 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.084Z | Extended Element | 5333596.3550784132,2184689.0489745466,360.95156198880801 | 70.8964 | 0.0134783 | 180 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.111Z | Extended Element | 5333596.2857634034,2184690.4558629394,360.95532330901074 | -89.1454 | -4.91727e-08 | -179.924 | -0.011397426255988498,-0.40985828498138588,-0.011397646929822057 | 0.011397386263543823,0.15586898078705913,1.0115241239008275
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.135Z | Extended Element | 5333596.7289156793,2184690.083017779,360.56484717181604 | 0.854767 | 90.0764 | 0.000375253 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.162Z | Extended Element | 5333596.7291208729,2184690.0830208375,360.26004657301496 | 0.854766 | 90.0764 | 0.000375366 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.191Z | Extended Element | 5333596.1426822254,2184690.4370580381,360.11217294061942 | -89.1454 | -7.12851e-07 | -89.924 | -0.011397387069976665,-1.830045625009489e-08,-0.011397655768444828 | 0.011397385490960733,0.16856029222363758,0.55432320282081604
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.218Z | Extended Element | 5333595.8812968982,2184689.7789258137,360.58103206455706 | 112.425 | -91.3612 | -48.4373 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.246Z | Extended Element | 5333595.8795175124,2184689.7738079731,360.32707969791124 | 112.425 | -91.3612 | -48.4374 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.272Z | Extended Element | 5333595.2232679976,2184687.8842678131,360.06389189537049 | -67.5749 | 91.3611 | 48.4375 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.300Z | Extended Element | 5333596.7484672023,2184689.7976915133,360.5756408382191 | 112.425 | -91.3612 | -48.4373 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.326Z | Extended Element | 5333596.7466878202,2184689.7925736718,360.3216884716133 | 112.425 | -91.3612 | -48.4374 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.354Z | Extended Element | 5333596.0904575782,2184687.9030891592,360.05850068295086 | -67.5749 | 91.3611 | 48.4375 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.383Z | Extended Element | 5333595.1332504964,2184685.1458262731,360.66838870017421 | -67.5743 | 91.3578 | 48.4369 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.407Z | Extended Element | 5333595.1332921395,2184685.1458944143,360.41438819721265 | -67.5744 | 91.3578 | 48.437 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.433Z | Extended Element | 5333595.235741647,2184685.4409954962,360.10404944305878 | -67.5746 | 91.3578 | 48.4371 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.462Z | Extended Element | 5333594.2663231604,2184685.1270106747,360.66831873502127 | -67.5743 | 91.3578 | 48.4369 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.487Z | Extended Element | 5333594.2663648017,2184685.1270788144,360.41431823205647 | -67.5744 | 91.3578 | 48.437 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.514Z | Extended Element | 5333594.3688183818,2184685.4221916259,360.10397925771281 | -67.5746 | 91.3578 | 48.4371 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.541Z | Extended Element | 5333593.4240877582,2184680.2226569843,360.61359935492374 | -67.8608 | 88.4815 | 48.7254 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.570Z | Extended Element | 5333593.4241194054,2184680.2227249737,360.35959885460824 | -67.8608 | 88.4815 | 48.7253 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.597Z | Extended Element | 5333593.526948751,2184680.5196187613,360.05487214923352 | -67.8606 | 88.4815 | 48.7252 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.624Z | Extended Element | 5333592.5571624804,2184680.2038414031,360.61359375289305 | -67.8608 | 88.4815 | 48.7254 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.650Z | Extended Element | 5333592.557194124,2184680.2039093915,360.35959325259688 | -67.8607 | 88.4815 | 48.7253 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.676Z | Extended Element | 5333592.6602101335,2184680.5013421089,360.05486668135723 | -67.8606 | 88.4815 | 48.7252 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.705Z | Extended Element | 5333592.5714885602,2184677.7667921749,360.56163007267446 | -67.8606 | 88.4787 | 48.7252 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.733Z | Extended Element | 5333592.5715162372,2184677.7668601056,360.30762957288374 | -67.8605 | 88.4786 | 48.7251 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.755Z | Extended Element | 5333592.6709477492,2184678.0539435293,360.00290042537557 | -67.8604 | 88.4786 | 48.725 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.780Z | Extended Element | 5333591.7025801456,2184677.7422567331,360.56155868343711 | -67.8606 | 88.4787 | 48.7252 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.806Z | Extended Element | 5333591.7026078207,2184677.7423246643,360.30755818366225 | -67.8605 | 88.4786 | 48.7251 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.835Z | Extended Element | 5333591.8047089642,2184678.0364223076,360.00896919912014 | -67.8604 | 88.4786 | 48.725 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.865Z | Extended Element | 5333591.9095374476,2184677.0826426507,360.96113040331181 | -89.1454 | -4.99876e-08 | -179.924 | -0.011397426255988498,-0.40985828498138588,-0.011397646929822057 | 0.011397386263543823,0.15586898078705913,1.0115241239008275
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.896Z | Extended Element | 5333591.7227486791,2184677.4593005986,360.56984279191306 | -179.145 | 89.9236 | 0.000593144 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.923Z | Extended Element | 5333592.3417653674,2184677.4685341641,360.26586819607024 | -179.145 | -90.0764 | 0.000729106 | -0.010185052040123014,-7.6686510767523724e-08,-0.010188482336681568 | 0.010185028678858702,0.40865370392057349,0.62930783763564069
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.951Z | Extended Element | 5333591.7659590458,2184677.097171701,360.11797561927352 | -89.1454 | -5.39036e-07 | -89.924 | -0.011397387069976665,-1.830045625009489e-08,-0.011397655768444828 | 0.011397385490960733,0.16856029222363758,0.55432320282081604
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.978Z | Extended Element | 5333592.7632251941,2184678.2623617556,360.11332850499872 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.987Z | Extended Element | 5333592.8242001766,2184678.4379966776,360.11675930938617 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:37.998Z | Extended Element | 5333592.8851751601,2184678.6136315982,360.12019011377345 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.007Z | Extended Element | 5333592.9461501399,2184678.7892665197,360.12362091816044 | 70.8964 | 0.0134789 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.019Z | Extended Element | 5333593.0071251243,2184678.9649014408,360.12705172254778 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.030Z | Extended Element | 5333593.0681001078,2184679.1405363609,360.13048252693477 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.066Z | Extended Element | 5333593.6178110745,2184680.7239470924,360.16137669097475 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.078Z | Extended Element | 5333593.6940296534,2184680.943490318,360.16565518060821 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.087Z | Extended Element | 5333593.7702482333,2184681.1630335446,360.1699336702419 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.097Z | Extended Element | 5333593.8464668142,2184681.3825767697,360.17421215987582 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.107Z | Extended Element | 5333593.9226853959,2184681.6021199957,360.17849064950934 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.135Z | Extended Element | 5333594.4724428412,2184683.1856646226,360.19372015304981 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.148Z | Extended Element | 5333594.5486380942,2184683.4051406528,360.19362348030836 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.158Z | Extended Element | 5333594.6248333436,2184683.6246166844,360.19352680756725 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.172Z | Extended Element | 5333594.7010285994,2184683.8440927141,360.19343013482626 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.182Z | Extended Element | 5333594.7772238515,2184684.0635687457,360.19333346208504 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.205Z | Extended Element | 5333595.3269781256,2184685.6471042288,360.17700781511331 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.215Z | Extended Element | 5333595.3879546989,2184685.8227437353,360.17343015486972 | 70.8964 | 0.0134786 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.225Z | Extended Element | 5333595.4489312731,2184685.9983832408,360.16985249462562 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.236Z | Extended Element | 5333595.5099078473,2184686.1740227481,360.16627483438168 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.247Z | Extended Element | 5333595.5708844215,2184686.3496622536,360.16269717413797 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.257Z | Extended Element | 5333595.6318609957,2184686.5253017601,360.15911951389432 | 70.8964 | 0.0134789 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.286Z | Extended Element | 5333596.1815635646,2184688.1086882981,360.12683225826305 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.297Z | Extended Element | 5333596.2425402533,2184688.2843281403,360.12324667343557 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.307Z | Extended Element | 5333596.3035169458,2184688.4599679816,360.11966108860832 | 70.8964 | 0.0134784 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.319Z | Extended Element | 5333596.3644936364,2184688.6356078242,360.11607550378096 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.330Z | Extended Element | 5333596.425470327,2184688.8112476654,360.112489918954 | 70.8964 | 0.0134784 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.339Z | Extended Element | 5333596.4864470176,2184688.9868875085,360.10890433412681 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.367Z | Extended Element | 5333592.0950487386,2184677.2362498646,360.00290046626333 | 0.854588 | -86.6957 | -0.00000122419 | -0.0099494431005378095,-4.2542286690947627e-11,-0.0099494396843274671 | 0.0099494390054477057,3.2036025226294713,0.91217912436103543
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.393Z | Extended Element | 5333592.9400065681,2184679.7046556342,360.05490343219043 | 0.854588 | -86.7363 | -0.00000126656 | -0.0099659487693956224,-5.7056675646727105e-11,-0.0099659455734878652 | 0.0099659446914429541,3.1966386282374475,0.92169951262588068
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.422Z | Extended Element | 5333593.7945922269,2184682.1662403443,360.1068105264884 | 0.854589 | -89.8206 | 6.29045e-08 | -0.0099641120669230736,1.4478472538955843e-10,-0.0099641106026897627 | 0.00996411206267739,3.1966386251019334,0.92022335831423263
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.450Z | Extended Element | 5333594.6491778893,2184684.6278250562,360.10966051429511 | 0.854589 | -92.906 | 2.65895e-08 | -0.0099655642363339868,-8.3801042346494615e-11,-0.0099655652335661343 | 0.0099655643142615505,3.1966386856398188,0.92139238988785832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.476Z | Extended Element | 5333596.3566119066,2184690.3060901882,360.01713293367629 | -179.145 | -87.0561 | 4.95129e-08 | -0.0099490548572008525,-1.8680592185062096e-10,-0.0099490547501268969 | 0.0099490548957463405,3.2036024659208731,0.91186905442410993
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.503Z | Extended Element | 5333564.2407816891,2184685.1834287453,360.15026657389012 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.517Z | Extended Element | 5333564.3169986941,2184685.4029674358,360.14614414369959 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.526Z | Extended Element | 5333564.393215701,2184685.6225061263,360.142021713509 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.537Z | Extended Element | 5333564.469432706,2184685.8420448173,360.13789928331846 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.547Z | Extended Element | 5333564.5456497129,2184686.0615835083,360.1337768531277 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.571Z | Extended Element | 5333564.1094132317,2184685.2455162127,360.99294876186957 | 70.8964 | 0.0134783 | 180 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.583Z | Extended Element | 5333563.6576032871,2184685.6479379958,360.98882474903007 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.592Z | Extended Element | 5333563.733820294,2184685.8674766896,360.98470231883999 | 70.8964 | -179.987 | 0.000162641 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.604Z | Extended Element | 5333563.8100372991,2184686.0870153792,360.98057988864917 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.615Z | Extended Element | 5333563.8862543078,2184686.3065540693,360.9764574584583 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.639Z | Extended Element | 5333564.4359717229,2184687.8899834626,360.94670346113656 | 70.8964 | -179.987 | 0.000162284 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.648Z | Extended Element | 5333564.5121886712,2184688.1095219865,360.94257097560353 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.658Z | Extended Element | 5333564.5884056184,2184688.3290605079,360.93843849007044 | 70.8964 | -179.987 | 0.000162579 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.669Z | Extended Element | 5333565.1926495153,2184688.3657159372,360.93430758718551 | 70.8964 | 0.0134783 | 180 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.681Z | Extended Element | 5333564.7408395102,2184688.7681375537,360.93017351900392 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.708Z | Extended Element | 5333565.0953671355,2184687.6450129142,360.10402354259242 | 70.8964 | 0.0134789 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.719Z | Extended Element | 5333565.1715840828,2184687.8645514366,360.09989105705932 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.730Z | Extended Element | 5333565.2478010282,2184688.0840899586,360.09575857152595 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.739Z | Extended Element | 5333565.3240179764,2184688.3036284805,360.09162608599257 | 70.8964 | 0.0134785 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.750Z | Extended Element | 5333565.4002349228,2184688.5231670039,360.08749360045942 | 70.8964 | 0.0134787 | -90.0002 | -0.011397381976983907,-1.5673563075439264e-09,-0.01139738086094534 | 0.011397381740335263,0.16856019587225418,0.85912407615293485
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.768Z | Smart Solid | 5333550.5444033872,2184686.8091286267,358.67173548133849 | -89.1454 | 0 | 0 | -0.31926331547798892,-3.0427323519693443,-22.250444500889003 | 7.6975074979803848,0.084266923185410736,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.780Z | Smart Solid | 5333551.1352665396,2184688.9021826028,358.82413548133843 | -89.1454 | 0 | 0 | -0.15999658127590255,-0.16266783388085271,-22.402844500889 | 0.15963165773902599,0.16280065527340604,-0.15239999999999998
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.792Z | Smart Solid | 5333547.1054491987,2184677.294526136,358.82413548133843 | -89.1454 | 0 | 0 | -0.15963165773899846,-0.16280065560077839,-22.402844500889 | 0.15999658127588123,0.16266783355341996,-0.15240000000000009
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.805Z | Smart Solid | 5333551.1352665396,2184688.9021826028,358.82413548133843 | -89.1454 | 0 | 0 | -0.15963165773901,-0.16267147282072258,-0.15239999999999998 | 0.15964165564414667,0.16266783396819706,0.45720121920243767
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.822Z | Smart Solid | 5333550.3020528005,2184686.8932652134,358.67173548133849 | -89.1454 | 0 | 0 | -0.23152146790923744,-2.801663607069302,0 | 7.7852493455491363,0.32533566808545356,0.60960121920243804
