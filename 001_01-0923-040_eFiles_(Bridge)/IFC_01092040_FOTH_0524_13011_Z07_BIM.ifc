Properties of the parts of a building model (IFC4X3_ADD2), part 32 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.836Z | Smart Solid | 5333547.1054491987,2184677.294526136,358.82413548133843 | -89.1454 | 0 | 0 | -0.15964165564411559,-0.16266783429557385,-0.15239999999999998 | 0.15963165773899668,0.16267147249328962,0.45720121920243767
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.852Z | Smart Solid | 5333606.8210502779,2184680.2695141775,358.72820158279046 | 90.8546 | 0 | 0 | -0.31926331547798897,-3.0427323523222278,-22.250444500889003 | 7.6975074979803866,0.084266922832526778,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.865Z | Smart Solid | 5333606.2301871236,2184678.1764602014,358.8806015827904 | 90.8546 | 0 | 0 | -0.15999658127590258,-0.16266783424465056,-22.402844500889 | 0.15963165773902602,0.16280065490960813,-0.15239999999999998
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.878Z | Smart Solid | 5333610.2600044673,2184689.7841166682,358.8806015827904 | 90.8546 | 0 | 0 | -0.15963165773899848,-0.16280065497868398,-22.402844500889 | 0.15999658127588126,0.16266783417551431,-0.15240000000000009
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.892Z | Smart Solid | 5333606.2301871236,2184678.1764602014,358.8806015827904 | 90.8546 | 0 | 0 | -0.15963165773901003,-0.16267147318452044,-0.15239999999999998 | 0.1596416556441467,0.16266783360439915,0.45720121920243767
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.908Z | Smart Solid | 5333607.0634008627,2184680.1853775904,358.72820158279046 | 90.8546 | 0 | 0 | -0.2315214679092375,-2.8016636074185475,0 | 7.7852493455491381,0.32533566773620753,0.60960121920243804
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:38.921Z | Smart Solid | 5333610.2600044673,2184689.7841166682,358.8806015827904 | 90.8546 | 0 | 0 | -0.15964165564411562,-0.16266783367347945,-0.15239999999999998 | 0.15963165773899671,0.16267147311538396,0.45720121920243767
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.047Z | Line | 5333551.053644212,2184689.2492854483,360.74993712669897 | 0 | 0 | 0 | 0,0,-0.9143998723498612 | 0.0018913401290774345,2.8212089091539383e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.056Z | Line | 5333550.1990585523,2184686.7877007355,360.79495876436226 | 0 | 0 | 0 | 0,0,-0.91439969452250125 | 0.0019754283130168915,2.9466580599546432e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.067Z | Line | 5333565.1745015876,2184689.4599191779,360.77915111131307 | 0 | 0 | 0 | 0,0,-0.91439987235537501 | 0.0018913373351097107,2.8211623430252075e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.075Z | Line | 5333565.1765337354,2184689.3773901411,360.39193015643644 | 0 | 0 | 0 | -0.002462443895637989,0,0 | 0,0.16508196666836739,6.8212102632969618e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.085Z | Line | 5333551.0556763588,2184689.166756412,360.36271617182501 | 0 | 0 | 0 | -0.0024624429643154144,0,0 | 0,0.1650819662027061,1.8758328224066645e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.093Z | Line | 5333551.0544451373,2184689.2492973949,360.362716171898 | 0 | 0 | 0 | 0,0,0 | 14.12085737567395,0.21063373051583767,0.029213984516786695
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.104Z | Line | 5333551.053644212,2184689.2492854488,360.74993712651155 | 0 | 0 | 0 | 0,0,0 | 14.12085737567395,0.21063372958451509,0.029213984768659884
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.114Z | Line | 5333550.1990585532,2184686.7877007364,360.79495876432475 | 0 | 0 | 0 | 0,0,0 | 14.120857372879982,0.21063372865319252,0.030512815490794765
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.123Z | Line | 5333564.3199159261,2184686.9983344651,360.82547157981554 | 0 | 0 | 0 | 0,0,-0.91439969452250125 | 0.0019754264503717422,2.9466580599546432e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.133Z | Line | 5333550.20112631,2184686.7051722314,360.40773788479265 | 0 | 0 | 0 | -0.0024624448269605637,0,-1.7053025658242404e-13 | 0,0.16508196527138352,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.143Z | Line | 5333564.3219836829,2184686.9158059605,360.43825070024576 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196527138352,1.0800249583553523e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.152Z | Line | 5333550.1998950876,2184686.7877132152,360.40773788478646 | 0 | 0 | 0 | 0,0,0 | 14.120857372879982,0.21063372865319252,0.03051281561374708
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.165Z | Extended Element | 5333557.8381313309,2184689.4330455814,360.31325303550165 | -179.145 | -0.118524 | 90 | 2.4167856437402364e-09,3.9286612096687549e-12,-4.8423169017218638e-09 | 0.33972500270308997,0.1270000010163603,0.012700004223173654
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.180Z | Extended Element | 5333557.8314579902,2184689.0392010934,360.2370269044182 | 0.855355 | 90.1185 | -0.00186478 | -6.2728988670102126e-13,-4.4987100156212989e-10,-1.4581771901056584e-09 | 0.27940000176630631,0.2285999983141043,0.15240000374615192
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.194Z | Extended Element | 5333557.783493408,2184689.4626794588,360.38612016738807 | -89.1454 | -0.00000157979 | 90 | 2.9578553495390736e-10,-1.4256304470272596e-13,-7.5446152797420396e-10 | 0.2492384995742904,0.044450000000003403,0.044450000293708311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.208Z | Extended Element | 5333557.7836247496,2184689.4626814188,360.32262030324165 | -89.1454 | -0.00000157979 | 90 | -5.1857954042056065e-10,-8.5712686948014039e-14,-8.1057763626213308e-10 | 0.24923849946249649,0.044450000000060254,0.044449999658536271
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.223Z | Extended Element | 5333557.6695513036,2184689.0367890266,360.23669194265682 | 0.855355 | 90.1185 | -0.00076484 | -2.0474455464380981e-12,4.2593975568827602e-10,-5.5879354476928711e-09 | 0.27940000168844348,0.22859999891251914,0.15239999855001662
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.238Z | Extended Element | 5333557.5963165993,2184689.4598874329,360.32223278831998 | -89.1454 | -0.00000157981 | 90 | -4.1705139341985387e-10,-1.329492071988625e-13,7.7185622476827476e-10 | 0.24923849932931291,0.044449999999960146,0.044450001252093994
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.252Z | Extended Element | 5333557.5961852539,2184689.4598854734,360.38573265237176 | -89.1454 | -0.00000157981 | 90 | -7.6531309067817688e-11,-1.3295961553971836e-13,-2.5642202944320402e-09 | 0.24923850037240408,0.044449999999960153,0.044449999782314467
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.267Z | Extended Element | 5333557.6370297875,2184689.1474414445,360.44300353336735 | 0.854041 | 0.118523 | 90 | 8.2110265808843508e-10,-2.1219588586252058e-12,-6.375726682716909e-10 | 0.090486502256792889,0.044449999999881799,0.044449999994019135
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.280Z | Extended Element | 5333557.6372136679,2184689.1474441905,360.35410372355761 | 0.854041 | 0.118523 | 90 | -9.8620091260048781e-11,-2.7171077887633288e-12,2.9374991675212847e-10 | 0.090486501337093378,0.044449999997605891,0.044450000560608167
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.293Z | Extended Element | 5333557.6373975482,2184689.1474469365,360.26520391379574 | 0.854041 | 0.118523 | 90 | 2.3218135747349322e-11,1.5931284069736762e-12,-6.353889983601313e-10 | 0.090486501461415347,0.044450000003694146,0.044449999763077612
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.304Z | Extended Element | 5333557.6668913038,2184687.1435971786,360.40167141673487 | 0.854041 | 0.118523 | 90 | -2.8457778494805908e-10,3.1249725029880437e-12,-1.2121033864109787e-09 | 0.090486499277589449,0.044450000003452311,0.044449999531077311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.318Z | Extended Element | 5333557.6670751851,2184687.1435999232,360.31277160692764 | 0.854041 | 0.118523 | 90 | -1.4453403682224142e-09,1.2488517164843671e-12,-2.8024502510270999e-10 | 0.090486498119310629,0.044450000003412087,0.044450000208719448
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.329Z | Extended Element | 5333557.6667074226,2184687.1435944326,360.49057122652124 | 0.854041 | 0.118523 | 90 | 5.6839765533167608e-10,1.0073088196893565e-12,1.6811627090440595e-10 | 0.090486501069833358,0.044450000003108323,0.044450000566582881
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.343Z | Extended Element | 5333557.7787414845,2184686.7877584198,360.43368787203036 | 90.8546 | 0.00000158685 | 90 | 3.4946656679579746e-10,-3.7882891268381513e-14,-9.8102716922232602e-11 | 0.24923650018959734,0.044450000000049436,0.044450001304769879
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.356Z | Extended Element | 5333557.7788728261,2184686.7877603834,360.37018800788394 | 90.8546 | 0.00000158685 | 90 | 4.5343850896273352e-10,1.9293594499814049e-14,2.404341656325748e-11 | 0.24923650029356928,0.04445000000007851,0.044450001507234521
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.370Z | Extended Element | 5333557.5914333342,2184686.7849644353,360.43330035703758 | 90.8546 | 0.00000158685 | 90 | 1.0454365151346678e-10,-8.1712414612411521e-14,-2.0023107824562736e-09 | 0.24923650017886487,0.044449999999992579,0.044449999480880326
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.384Z | Extended Element | 5333557.5915646749,2184686.784966398,360.36980049296216 | 90.8546 | 0.00000158685 | 90 | 1.1425576318391251e-09,-8.1712414612411521e-14,-1.6057710924832769e-09 | 0.2492365007484981,0.044449999999992579,0.044449999877420016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.399Z | Extended Element | 5333557.5441960189,2184687.2084519281,360.28394438742635 | -179.145 | 89.8815 | -0.00186478 | -1.7694964660197599e-09,-2.9043634164338528e-10,9.3377736098965158e-10 | 0.27939999999743703,0.22859999904749947,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.414Z | Extended Element | 5333557.7061027093,2184687.2108639954,360.28427934923337 | -179.145 | 89.8815 | -0.00076484 | -1.6915768230596484e-09,-2.1033205732656768e-10,-5.7165712741093699e-09 | 0.27939999999891402,0.22859999978991294,0.15239999979410812
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.425Z | Extended Element | 5333557.8770877691,2184686.8069692738,360.36082070424357 | -179.145 | -0.118524 | 90 | -4.1886326004004618e-10,7.4542931405089579e-13,-3.8661319882115898e-09 | 0.3397249998665034,0.12700000101317674,0.012700004190307153
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.436Z | Line | 5333557.6680254005,2184689.4305081968,360.43990138273637 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.445Z | Line | 5333560.0098562213,2184689.4325016052,360.40393570594688 | 0 | 0 | 0 | 0,0,-0.12699972827999773 | 0.00026268139481544495,3.9190053939819336e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.455Z | Line | 5333551.0532139158,2184689.3318383782,360.36271617189897 | 0 | 0 | 0 | 0,0,0 | 14.120857376605272,0.21063373051583767,0.029213984516786695
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.465Z | Line | 5333557.7067924235,2184686.8171304753,360.48746905152035 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.474Z | Line | 5333549.3444728944,2184684.3261160231,360.8399815196579 | 0 | 0 | 0 | 0,0,-0.91439952562552662 | 0.0020521003752946854,3.0610710382461548e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.482Z | Line | 5333548.4898872338,2184681.8645313131,360.83606012511035 | 0 | 0 | 0 | 0,0,-0.914399367294493 | 0.0021214643493294716,3.1644944101572037e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.490Z | Line | 5333547.6353015741,2184679.4029466016,360.78319509063391 | 0 | 0 | 0 | 0,0,-0.91439922127318596 | 0.0021834820508956909,3.2569281756877899e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.498Z | Line | 5333546.7807159154,2184676.9413618864,360.73033002313593 | 0 | 0 | 0 | 0,0,-0.91439908903612377 | 0.0022381618618965149,3.3385585993528366e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.506Z | Line | 5333563.4653302683,2184684.5367497527,360.87167869223612 | 0 | 0 | 0 | 0,0,-0.91439952562370763 | 0.0020521022379398346,3.061024472117424e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.516Z | Line | 5333562.6107446058,2184682.0751650413,360.86882870394874 | 0 | 0 | 0 | 0,0,-0.91439936729085503 | 0.0021214662119746208,3.1644944101572037e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.524Z | Line | 5333561.7561589479,2184679.6135803293,360.81692160945033 | 0 | 0 | 0 | 0,0,-0.91439922127409545 | 0.0021834811195731163,3.2569281756877899e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.533Z | Line | 5333560.9015732901,2184677.1519956179,360.76490117004653 | 0 | 0 | 0 | 0,0,-0.91439908903424794 | 0.0022381646558642387,3.3385585993528366e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.541Z | Line | 5333549.3441106761,2184684.4086699691,360.45276071161135 | 0 | 0 | 0 | 0,-0.1650819662027061,-5.6843418860808015e-14 | 0.0024624448269605637,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.550Z | Line | 5333548.4895543875,2184681.9470856972,360.44883938411061 | 0 | 0 | 0 | 0,-0.16508196573704481,0 | 0.0024624457582831383,0,1.7053025658242404e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.560Z | Line | 5333547.6349949902,2184679.4855013769,360.39597441146975 | 0 | 0 | 0 | 0,-0.16508196573704481,-1.7053025658242404e-13 | 0.0024624466896057129,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.570Z | Line | 5333546.7804324878,2184677.0239170073,360.34310939997488 | 0 | 0 | 0 | 0,-0.16508196573704481,-1.9326762412674725e-12 | 0.0024624448269605637,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.582Z | Line | 5333563.464968049,2184684.6193036982,360.48445788419076 | 0 | 0 | 0 | 0,-0.16508196573704481,0 | 0.0024624448269605637,0,3.4106051316484809e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.592Z | Line | 5333562.6104117613,2184682.1577194254,360.48160796295326 | 0 | 0 | 0 | 0,-0.1650819662027061,-1.0231815394945443e-12 | 0.002462443895637989,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.602Z | Line | 5333561.755852364,2184679.6961351046,360.42970093028788 | 0 | 0 | 0 | 0,-0.16508196573704481,0 | 0.002462443895637989,0,1.7053025658242404e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.610Z | Line | 5333560.9012898635,2184677.2345507392,360.37768054688394 | 0 | 0 | 0 | 0,-0.1650819662027061,0 | 0.0024624448269605637,0,2.2737367544323206e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.620Z | Line | 5333549.3453418985,2184684.3261289871,360.45276071115683 | 0 | 0 | 0 | 0,0,0 | 14.120857373811305,0.21063372818753123,0.031697173551265223
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.631Z | Line | 5333548.4907856099,2184681.8645447129,360.44883938447595 | 0 | 0 | 0 | 0,0,0 | 14.120857372879982,0.21063372865319252,0.032768578299624096
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.640Z | Line | 5333547.6362262135,2184679.402960394,360.39597441135436 | 0 | 0 | 0 | 0,0,0 | 14.120857372879982,0.21063372725620866,0.033726519090578222
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.650Z | Line | 5333546.7816637103,2184676.9413760244,360.34310939958942 | 0 | 0 | 0 | 0,0,0 | 14.120857376605272,0.21063373144716024,0.034571147472718167
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.659Z | Line | 5333558.1148738246,2184689.3546142597,360.37732316415639 | 0 | 0 | 0 | -0.85455005057156086,-2.461584179662168,0 | 0,0,0.045671128436879371
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.668Z | Line | 5333557.2603237741,2184686.89303008,360.42299429259327 | 0 | 0 | 0 | -0.85455318912863731,-2.4615842290222645,0 | 0,0,0.045615005339186609
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.677Z | Line | 5333556.4057705849,2184684.431445851,360.46860929793246 | 0 | 0 | 0 | -0.85455628857016563,-2.4615842732600868,-0.0033856243067020841 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.687Z | Line String | 5333556.8330471795,2184685.662237966,360.44580179526287 | 0 | 0 | 0 | -0.018259970471262932,0,-0.023770126853605689 | 0,1.2241470017470419,7.503331289626658e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.697Z | Line | 5333550.1986638652,2184686.8702541981,360.40773788478634 | 0 | 0 | 0 | 0,0,0 | 14.120857373811305,0.21063372865319252,0.03051281561374708
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.706Z | Line | 5333549.3441106761,2184684.40866997,360.45276071115688 | 0 | 0 | 0 | 0,0,0 | 14.120857373811305,0.21063372818753123,0.031697173551265223
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.717Z | Line | 5333548.4895543875,2184681.9470856972,360.44883938411061 | 0 | 0 | 0 | 0,0,0 | 14.120857373811305,0.21063372865319252,0.032768578299624096
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.725Z | Line | 5333547.6349949902,2184679.4855013769,360.39597441146975 | 0 | 0 | 0 | 0,0,0 | 14.120857373811305,0.21063372725620866,0.033726519090635065
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.735Z | Line | 5333546.7804324878,2184677.0239170073,360.34310939997488 | 0 | 0 | 0 | 0,0,0 | 14.12085737567395,0.21063373144716024,0.034571147472718167
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.743Z | Line | 5333556.8148363763,2184686.8863849686,360.42203166870081 | 0 | 0 | 0 | -0.0012312224134802818,0,0 | 0,0.082540981471538544,3.979039320256561e-13
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.752Z | Line String | 5333556.8330471795,2184685.662237966,360.44580179526287 | 0 | 0 | 0 | 0,-1.141606021206826,-3.751665644813329e-12 | 0.017028747126460075,0,0.023807490595345371
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.763Z | Line | 5333556.8522408344,2184684.355546271,360.53309920190605 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.92179936170578e-06,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.774Z | Extended Element | 5333557.02253618,2184684.345385069,360.40645085462933 | -179.145 | -0.118524 | 90 | 8.4917441482189757e-10,5.5771199172195771e-12,-3.8661319882115898e-09 | 0.33972500113454107,0.12700000101800843,0.012700003258984578
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.789Z | Extended Element | 5333556.7368817432,2184684.3233802314,360.47893050742323 | 90.8546 | 0.00000158685 | 90 | -4.9162307558248131e-10,-9.4715901788333667e-14,-1.4436930123595815e-09 | 0.24923649911431739,0.044449999999964476,0.044450000033853104
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.802Z | Extended Element | 5333556.7370130867,2184684.3233821932,360.41543064334786 | 90.8546 | 0.00000158685 | 90 | -1.5618017989993405e-10,-3.7882891268381513e-14,-1.0489903494448338e-09 | 0.24923649968395059,0.044450000000021334,0.044449999776931773
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.814Z | Extended Element | 5333556.9241898954,2184684.3261742145,360.47931802241595 | 90.8546 | 0.00000158685 | 90 | -1.5229290051266275e-11,-2.5202062658991053e-14,-2.3536495807885416e-09 | 0.24923649959071117,0.044450000000049103,0.044449999054868183
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.827Z | Extended Element | 5333556.924321237,2184684.3261761782,360.41581815826964 | 90.8546 | 0.00000158685 | 90 | 5.5440393942340904e-10,-8.2045481519799068e-14,-3.5777437956685532e-10 | 0.2492365001603444,0.04444999999999226,0.044450000468147746
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.841Z | Extended Element | 5333556.8515511192,2184684.7492797906,360.32990949961913 | -179.145 | 89.8815 | -0.00076484 | -1.6927705348557254e-09,8.5794360504820588e-10,-4.6566128730773926e-09 | 0.27939999999772031,0.22860000026362631,0.15239999988603214
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.857Z | Extended Element | 5333556.6896444289,2184684.7468677228,360.32957453780892 | -179.145 | 89.8815 | -0.00186478 | -1.7687574876967815e-09,-1.0292097729625027e-10,1.869113031016667e-09 | 0.279399999998176,0.22859999877976558,0.1524000084027648
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.872Z | Extended Element | 5333556.8121558335,2184684.6820102278,360.53620137690518 | 0.854041 | 0.118523 | 90 | -1.8103749818698667e-09,2.2450791226091837e-12,1.8541626567447622e-10 | 0.090486498691037517,0.044450000004408317,0.044450000674380742
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.888Z | Extended Element | 5333556.8123397119,2184684.6820129743,360.44730156711461 | 0.854041 | 0.118523 | 90 | -8.3787001642354753e-10,2.2176392666661826e-12,-1.6919191048181403e-10 | 0.090486501534604927,0.044450000004246683,0.044450000097666344
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.901Z | Extended Element | 5333556.812523596,2184684.6820157184,360.35840175731329 | 0.854041 | 0.118523 | 90 | -2.1517402928883378e-09,-9.6482544176268448e-13,-6.3810846537282195e-10 | 0.090486497412933908,0.044450000001136192,0.044450000462929268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.913Z | Extended Element | 5333556.7826620787,2184686.6858599852,360.39973387394338 | 0.854041 | 0.118523 | 90 | -4.4162526413593639e-10,-1.8666249101961796e-12,-2.8078081526494714e-10 | 0.090486500994064967,0.044449999998460714,0.04445000022820951
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.926Z | Extended Element | 5333556.7828459609,2184686.6858627317,360.3108340641873 | 0.854041 | 0.118523 | 90 | -4.8538314340040856e-10,-7.8689138538479142e-13,-2.8024502510270999e-10 | 0.090486499079267854,0.044450000001376347,0.044450000208719448
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.939Z | Extended Element | 5333556.7824781993,2184686.6858572401,360.48863368375305 | 0.854041 | 0.118523 | 90 | -6.3442787134881939e-10,2.2744826855269906e-12,1.8488048245113298e-10 | 0.090486499864524075,0.044450000002597495,0.044450000674916529
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.954Z | Extended Element | 5333556.976906402,2184686.5776168886,360.2826570548055 | 0.855355 | 90.1185 | -0.00186478 | -1.7641582639171816e-12,-1.1030455437932574e-09,9.307631332333699e-10 | 0.27940000176516944,0.22859999738358006,0.15240000654011965
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.970Z | Extended Element | 5333556.8149997136,2184686.5752048218,360.28232209304252 | 0.855355 | 90.1185 | -0.00076484 | -6.9359795684675873e-12,-6.4233590668649754e-10,-3.7252902984619141e-09 | 0.27940000168355494,0.22859999860093008,0.15240000016094624
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.983Z | Extended Element | 5333556.7416336648,2184686.9983012681,360.43136280275741 | -89.1454 | -0.00000157979 | 90 | 4.4259651499345409e-10,-1.4255610580882205e-13,-4.5230741721469236e-10 | 0.24923850018948213,0.04445000000000341,0.044450000951819689
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:39.999Z | Extended Element | 5333556.7417650083,2184686.9983032281,360.36786293870563 | -89.1454 | -0.00000157979 | 90 | -1.3213927174682283e-10,-1.4255610580882205e-13,-8.2149157268340822e-10 | 0.24923849914636559,0.04445000000000341,0.044449999647622335
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.012Z | Extended Element | 5333556.928941817,2184687.0010952549,360.43175031777383 | -89.1454 | -0.00000157981 | 90 | 7.5146286415694874e-10,2.3293866835416566e-14,-7.8168017891844244e-10 | 0.24923850096620787,0.04445000000007384,0.044450001195856757
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.023Z | Extended Element | 5333556.9290731596,2184687.0010972144,360.36825045362752 | -89.1454 | -0.00000157981 | 90 | 4.082233995283957e-10,-3.3549552025391449e-14,-8.5251935372232523e-10 | 0.24923850038877804,0.044450000000016997,0.044449999627718409
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.033Z | Extended Element | 5333556.9835797418,2184686.9714613766,360.35888318588741 | -179.145 | -0.118524 | 90 | 2.7535008550090041e-09,3.7581309530863308e-12,-4.3766556144141246e-09 | 0.33972500303980518,0.12700000101618977,0.012700004223173654
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.041Z | Line | 5333556.8134738114,2184686.9689239925,360.48553153312213 | 0 | 0 | 0 | 0,0,-0.12699972828636419 | 0.00026268698275089264,3.9180740714073181e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.050Z | Line | 5333556.8500266857,2184684.5206319443,360.46960928534611 | 0 | 0 | 0 | 0,-0.16508196759968996,-2.2737367544323206e-13 | 0.0024624448269605637,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.058Z | Line | 5333548.4920168323,2184681.7820037301,360.44883938515676 | 0 | 0 | 0 | 0,0,0 | 14.120857372879982,0.21063372865319252,0.032768578299624096
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.068Z | Line String | 5333555.9784924407,2184683.2006537141,360.46691648577911 | 0 | 0 | 0 | 0,-1.2241462683305144,-0.00065890202620266791 | 0.018261454068124294,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.076Z | Line String | 5333555.9784924407,2184683.2006537141,360.46691648577911 | 0 | 0 | 0 | -0.018261528573930264,0,0 | 0,1.2241462683305144,0.00069270746166694153
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.086Z | Line | 5333555.9602309139,2184684.4247999596,360.4676091919884 | 0 | 0 | 0 | -0.0012312205508351326,0,-7.3896444519050419e-13 | 0,0.082540982868522406,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.095Z | Line | 5333555.9967538957,2184681.9765074672,360.46625758336546 | 0 | 0 | 0 | 0,-0.082540982402861118,-1.8758328224066645e-12 | 0.0012312214821577072,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.110Z | Extended Element | 5333556.0698028384,2184681.8645924679,360.47597626871442 | 90.8546 | 0.00000158685 | 90 | 3.5516031782201196e-10,-2.5202062658991053e-14,-1.665532815831039e-09 | 0.24923650042948153,0.044450000000007983,0.044449999011042289
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.122Z | Extended Element | 5333556.0699341819,2184681.8645944316,360.41247640456805 | 90.8546 | 0.00000158685 | 90 | 4.5913225998894802e-10,-2.4868995751603507e-14,-1.3365606607584901e-09 | 0.24923650053345348,0.044450000000008316,0.044450000146630447
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.134Z | Extended Element | 5333555.882494688,2184681.8617984848,360.47558875372169 | 90.8546 | 0.00000158685 | 90 | 5.7861823665739109e-10,7.5803946453234516e-14,-2.4243163206094653e-09 | 0.24923650041874901,0.04445000000013502,0.044449999058874784
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.148Z | Extended Element | 5333555.8826260306,2184681.8618004466,360.41208888964627 | 90.8546 | 0.00000158685 | 90 | 6.8259017882432715e-10,1.0487444246365385e-13,-1.7240743901969502e-10 | 0.24923650052272095,0.044450000000192197,0.044450001310783666
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.162Z | Extended Element | 5333555.997164065,2184682.287698044,360.3265677459176 | -179.145 | 89.8815 | -0.00076484 | -1.6906104710612269e-09,1.890021472661374e-11,-7.4505805969238281e-09 | 0.27939999999988036,0.22859999979796503,0.15240000019644953
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.174Z | Extended Element | 5333555.8352573747,2184682.2852859767,360.32623278411057 | -179.145 | 89.8815 | -0.00186478 | -1.7684732844802653e-09,-3.4359398659589147e-10,6.5522029468745302e-10 | 0.27939999999846021,0.22859999937283007,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.186Z | Extended Element | 5333556.1681491258,2184681.8838033224,360.40310910092774 | -179.145 | -0.118524 | 90 | -1.8077271276240994e-10,9.1595957063331983e-13,-2.9348094135961112e-09 | 0.33972500010459394,0.12700000101334727,0.012700004190307153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.202Z | Extended Element | 5333556.1223009396,2184684.1160318805,360.32823457845649 | 0.855355 | 90.1185 | -0.00186478 | 5.0957849051513904e-13,1.0288028762239776e-10,1.7145427577691663e-09 | 0.27940000176744317,0.22859999858950589,0.15240000654011965
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.219Z | Extended Element | 5333555.9603942502,2184684.1136198137,360.32789961669675 | 0.855355 | 90.1185 | -0.00076484 | -8.5373375036112975e-13,-7.8074222087387568e-10,-6.5192580223083496e-09 | 0.27940000168963719,0.22859999770583717,0.15239999905937274
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.233Z | Extended Element | 5333555.8870282033,2184684.5367162605,360.47694032641175 | -89.1454 | -0.00000157981 | 90 | -2.8896246506704415e-11,-1.893971091071478e-14,-2.3514165857496661e-09 | 0.24923850018584875,0.044450000000074166,0.044449999058356685
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.244Z | Extended Element | 5333555.8871595487,2184684.53671822,360.41344046236003 | -89.1454 | -0.00000157981 | 90 | 7.9337716951677351e-10,-1.8945955915228296e-13,5.1536420964115592e-11 | 0.2492385005397415,0.044449999999960806,0.044450001461309688
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.256Z | Extended Element | 5333556.0743363546,2184684.5395102464,360.47732784142801 | -89.1454 | -0.00000157979 | 90 | -1.7560979614916761e-09,-1.4256304470272596e-13,-1.7094490094293757e-09 | 0.24923849799078768,0.044450000000003403,0.044450000273733928
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.269Z | Extended Element | 5333556.0744676981,2184684.5395122063,360.41382797728164 | -89.1454 | -0.00000157979 | 90 | -4.6818859900099596e-10,-1.4255610580882205e-13,8.072717147533659e-11 | 0.24923849881031629,0.04445000000000341,0.044450000549841079
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.282Z | Extended Element | 5333556.1289742803,2184684.5098763686,360.40446070954164 | -179.145 | -0.118524 | 90 | 7.2799971513969048e-11,1.7117678740972423e-12,-5.7736394763373424e-09 | 0.3397250003591043,0.12700000101414341,0.012700003757512367
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.289Z | Line | 5333555.958868349,2184684.5073389844,360.53110905677636 | 0 | 0 | 0 | 0,0,-0.12699972828636419 | 0.00026268698275089264,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.300Z | Line | 5333555.9978537783,2184681.8939645244,360.52975744820446 | 0 | 0 | 0 | 0,0,-0.12699972827078909 | 0.00026268512010574341,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.309Z | Line | 5333557.6875987994,2184688.1238221698,360.40015872837483 | 0 | 0 | 0 | -0.018259975127875805,0,0 | 0,1.2241462678648531,9.2285290520521812e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.324Z | Line | 5333557.6693388242,2184689.3479684377,360.40015872929769 | 0 | 0 | 0 | 0,0,-0.023757210384587779 | 4.9139373004436493e-05,7.3295086622238159e-07,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.333Z | Line | 5333555.9460818078,2184684.2023162078,360.4675730513444 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.224252186688318e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.342Z | Line | 5333555.9759778501,2184682.1984724593,360.46622146716965 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.2242519934206939e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.352Z | Line | 5333557.837679226,2184689.4457402457,360.44025276513617 | 0 | 0 | 0 | 0,0,-0.12699972827039119 | 0.00026268605142831802,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.360Z | Line | 5333556.830181025,2184684.6600514585,360.55846303065687 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053667604923248,7.2242518342591211e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.370Z | Line | 5333556.8303649034,2184684.660054205,360.46956322086533 | 0 | 0 | 0 | 0,0,0 | 0.034919046796858311,0.00052053621038794518,7.2242523799559422e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.380Z | Line | 5333556.8305487875,2184684.6600569496,360.38066341106304 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.2242518456278049e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.389Z | Line | 5333556.8008711524,2184686.6639039628,360.33309571793529 | 0 | 0 | 0 | 0,0,0 | 0.034919044002890587,0.00052053621038794518,7.2242516466758389e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.398Z | Line | 5333556.8006872702,2184686.6639012164,360.42199552769216 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.2242521810039761e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.407Z | Line | 5333556.8005033918,2184686.6638984708,360.51089533750564 | 0 | 0 | 0 | 0,0,0 | 0.034919044002890587,0.00052053621038794518,7.2242518001530698e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.417Z | Line | 5333555.9761617305,2184682.1984752035,360.37732165735957 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.224251839943463e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.427Z | Line | 5333555.9757939698,2184682.1984697124,360.55512127695721 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.224251839943463e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.436Z | Line | 5333555.9462656891,2184684.2023189547,360.37867324158935 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.224251839943463e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.448Z | Line | 5333555.9460818078,2184684.2023162078,360.4675730513444 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.224252186688318e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.455Z | Line | 5333555.9458979275,2184684.2023134632,360.55647286115601 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.224252186688318e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.467Z | Line | 5333555.9458979275,2184684.2023134632,360.55647286115601 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.224252186688318e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.474Z | Line | 5333547.6374574369,2184679.3204194116,360.39597441204256 | 0 | 0 | 0 | 0,0,0 | 14.120857372879982,0.21063372725620866,0.033726519090578222
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.486Z | Line | 5333555.5512142964,2184681.9698615777,360.46522367362576 | 0 | 0 | 0 | -0.85455939639359713,-2.4615843198262155,-0.052386002726166225 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.494Z | Line | 5333555.1056225859,2184681.9632149101,360.46418964257492 | 0 | 0 | 0 | -0.0012312224134802818,0,0 | 0,0.082540983334183693,6.1788796301698312e-11
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.508Z | Extended Element | 5333555.2197280256,2184682.0779251973,360.47390829128904 | -89.1454 | -0.00000157981 | 90 | 5.7425231236862828e-11,-1.8979609550662246e-13,-1.9658242360331979e-09 | 0.24923849980378954,0.044449999999903303,0.044450000011712704
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.522Z | Extended Element | 5333555.0324198753,2184682.0751312114,360.47352077627261 | -89.1454 | -0.00000157979 | 90 | -2.5414373383547684e-10,-1.4222303890143451e-13,9.1929933110357354e-10 | 0.24923849949274191,0.044449999999946567,0.044450001388413235
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.536Z | Extended Element | 5333555.032551216,2184682.0751331719,360.41002091222083 | -89.1454 | -0.00000157979 | 90 | 9.9723618252056667e-11,-8.5379620040626492e-14,-3.7227188345867468e-10 | 0.24923849984660923,0.04445000000000341,0.044450001031855223
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.551Z | Extended Element | 5333555.2198593682,2184682.0779271573,360.41040842714267 | -89.1454 | -0.00000157981 | 90 | 8.7697923922824828e-10,-1.8945955915228296e-13,-1.631542886904036e-10 | 0.24923850062334357,0.044449999999903629,0.044450001246618978
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.566Z | Extended Element | 5333555.2676926106,2184681.6544468324,360.32481502832059 | 0.855355 | 90.1185 | -0.00186478 | -1.4799411696131415e-12,-1.0586710119664389e-09,-2.5521330326849778e-09 | 0.27940000176545365,0.22859999790077737,0.1524000046774745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.585Z | Extended Element | 5333555.1057859221,2184681.6520347646,360.32448006655778 | 0.855355 | 90.1185 | -0.00076484 | -4.6053993951744587e-12,5.2181420295838166e-10,-5.5879354476928711e-09 | 0.27940000168588552,0.22859999979796503,0.15239999907152385
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.603Z | Extended Element | 5333555.2743659504,2184682.0482913204,360.40104115940261 | -179.145 | -0.118524 | 90 | 1.529634735449402e-09,4.440251979416027e-12,-6.2393007636450816e-09 | 0.33972500181593906,0.12700000101687189,0.012700002826189792
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.615Z | Extended Element | 5333555.1425397322,2184679.8261127528,360.27421185094352 | -179.145 | 89.8815 | -0.00076484 | -1.6918609846428012e-09,-3.9798947470970347e-10,-5.5879354476928711e-09 | 0.27939999999862974,0.22859999840098116,0.15239999992021575
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.629Z | Extended Element | 5333554.9806330428,2184679.8237006855,360.27387688913478 | -179.145 | 89.8815 | -0.00186478 | -1.7643236593922751e-09,-7.829165094008772e-11,1.4648063317856952e-10 | 0.27940000000260967,0.22859999877976558,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.642Z | Extended Element | 5333555.0280016987,2184679.4002151554,360.35973299467213 | 90.8546 | 0.00000158685 | 90 | -5.3597210003530904e-10,-8.2045481519799068e-14,-9.1275417432590267e-10 | 0.24923649953834912,0.044449999999992246,0.044449999924457945
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.655Z | Extended Element | 5333555.0278703561,2184679.4002131941,360.42323285874755 | 90.8546 | 0.00000158685 | 90 | 6.2627070196441537e-11,-1.3888890038060708e-13,-1.3201717115329803e-09 | 0.24923649943437715,0.044449999999935402,0.044450001099780895
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.668Z | Extended Element | 5333555.2151785064,2184679.4030071772,360.42362037374028 | 90.8546 | 0.00000158685 | 90 | -3.9502115467549004e-10,1.8960527592426502e-14,-5.5958725500571127e-10 | 0.24923649944510962,0.044450000000078177,0.044450000116987839
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.681Z | Extended Element | 5333555.2153098499,2184679.4030091413,360.36012050959391 | 90.8546 | 0.00000158685 | 90 | -7.5399106402862515e-10,-9.4715901788333667e-14,-2.0841833502094342e-09 | 0.24923649861775901,0.044449999999964476,0.044449998753028769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.694Z | Extended Element | 5333555.3135247929,2184679.4222180312,360.35075320595365 | -179.145 | -0.118524 | 90 | 2.0278687793205467e-09,2.2802019162480319e-12,-2.469148126288372e-09 | 0.33972500231323538,0.1270000010147114,0.01270000465596844
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.702Z | Line | 5333555.1432294464,2184679.4323792332,360.47740155323038 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.92179936170578e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.711Z | Line | 5333555.10426002,2184682.0457539354,360.52768950663727 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9180740714073181e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.721Z | Line | 5333555.1422465472,2184679.5149239246,360.41390193081037 | 0 | 0 | 0 | 0,-0.082540982868522406,-6.1504579207394272e-11 | 0.0012312224134802818,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.728Z | Line | 5333555.0912895994,2184681.7407284137,360.55305331101886 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.2242519934206939e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.738Z | Line | 5333555.0914734788,2184681.7407311597,360.46415350120731 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.224252186688318e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.747Z | Line | 5333555.0916573601,2184681.7407339057,360.37525369144856 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.2242520275267452e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.755Z | Line | 5333555.1215373985,2184679.7368899118,360.32496576238555 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.2242518342591211e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.766Z | Line | 5333555.1213535164,2184679.7368871672,360.41386557219164 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053667604923248,7.224252186688318e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.774Z | Line | 5333555.121169637,2184679.7368844212,360.50276538198108 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.224252038895429e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.785Z | Line | 5333555.1435768297,2184679.7372184489,360.41391154947615 | 0 | 0 | 0 | -0.029880291782319546,0,0 | 0,2.0038439887575805,0.050287927977706204
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.793Z | Line | 5333555.144182587,2184679.6965949642,360.41289207347228 | 0 | 0 | 0 | -0.031091805547475815,0,0 | 0,2.0850909580476582,0.052326879985400865
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.806Z | Extended Element | 5333555.0587188974,2184679.7048834641,360.22239500496511 | 90.8543 | 1.43742 | 89.8814 | -1.0736886953298833e-09,2.4442670110147446e-12,-3.4986961938709982e-10 | 2.0859791718082752,0.38100000001662931,0.085724999650103606
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.817Z | Line | 5333557.7082129251,2184687.0813186527,360.19725332884479 | 0 | 0 | 0 | -0.00089397653937339783,-1.3346318155527115e-05,0 | 0,0,0.43220749265123004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.837Z | Extended Element | 5333556.7680045031,2184684.6094201393,360.28015058268716 | 90.8486 | -1.35963 | 89.8816 | 1.5273116084314793e-10,4.0927261579781771e-12,6.6540317700258811e-10 | 2.0859791726473316,0.38100000000584577,0.085726445611058258
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.851Z | Extended Element | 5333555.8815862797,2184684.2423159406,360.65796887905196 | -89.1453 | -0.0386396 | -89.8815 | -9.3626861852478559e-10,-8.6402001165412094e-12,8.1409971819379479e-10 | 2.0859791704951585,0.38100000000569145,0.085725000814071528
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.861Z | Line | 5333554.2510616388,2184679.501630567,360.41177340751909 | 0 | 0 | 0 | 0,0,0 | 0,0.082559304311871529,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.872Z | Extended Element | 5333554.4210362276,2184679.5867282306,360.34862492482432 | -179.145 | -0.118524 | 90 | 1.3818399590321593e-09,6.3160843624082201e-12,-6.2393007636450824e-09 | 0.33972500166814434,0.12700000101874775,0.012700003291851079
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.884Z | Extended Element | 5333554.4210362276,2184679.5867282306,360.34862492482432 | -179.145 | -0.118524 | 90 | 1.3818399590321593e-09,6.3160843624082201e-12,-6.2393007636450824e-09 | 0.33972500166814434,0.12700000101874775,0.012700003291851079
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.898Z | Extended Element | 5333554.1792214932,2184679.6135700829,360.35760467764248 | -89.1454 | -0.00000157979 | 90 | -1.4831868788700575e-09,-1.4256304470272596e-13,-1.7021730518151923e-09 | 0.24923849849788915,0.044449999999946227,0.044450000281009885
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.914Z | Extended Element | 5333554.1790901516,2184679.6135681216,360.42110454169432 | -89.1454 | -0.00000157979 | 90 | -2.0316051618785025e-10,-1.4222997779533841e-13,-4.0521556249339952e-10 | 0.24923849907534434,0.04444999999994656,0.044450001577967371
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.927Z | Extended Element | 5333554.3663983028,2184679.6163621084,360.4214920567108 | -89.1454 | -0.00000157981 | 90 | 1.0570994080083551e-10,-1.9262369477246466e-14,2.0796950966905925e-10 | 0.24923849985207425,0.044450000000073833,0.044450000688207279
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.941Z | Extended Element | 5333554.3665296445,2184679.6163640679,360.35799219256432 | -89.1454 | -0.00000157981 | 90 | 4.5960263372890608e-10,-1.926583892419842e-14,-1.3710327456672999e-09 | 0.24923850020596694,0.044450000000073833,0.044450000606504191
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.952Z | Line | 5333554.2509302963,2184679.584190846,360.47527327205898 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9185397326946259e-06,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.967Z | Extended Element | 5333554.2524561984,2184679.1904716752,360.27206383197944 | 0.855355 | 90.1185 | -0.00076484 | -2.6726815205435628e-12,5.7150950638629183e-12,-6.5192580223083496e-09 | 0.27940000168781809,0.22859999887049159,0.15239999732532167
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:40.982Z | Extended Element | 5333554.414362886,2184679.192883743,360.27239879373917 | 0.855355 | 90.1185 | -0.00186478 | 5.664635427393705e-13,-8.6237747498607575e-10,9.9179722767850365e-10 | 0.27940000176749991,0.22859999784844301,0.15240000576924181
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.000Z | Extended Element | 5333554.2893270291,2184677.3645485225,360.22179906564338 | -179.145 | 89.8815 | -0.00076484 | -1.6914631639775024e-09,-3.4764691125843683e-10,-8.3819031715393066e-09 | 0.27939999999902776,0.22859999889561908,0.15239999829155276
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.016Z | Extended Element | 5333554.1274203379,2184677.3621364548,360.22146410383471 | -179.145 | 89.8815 | -0.00186478 | -1.7638689814303277e-09,-2.7481736331047557e-10,-5.3989834825074468e-10 | 0.27940000000306464,0.2285999983141043,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.030Z | Extended Element | 5333554.1747889938,2184676.9386509247,360.30732020937205 | 90.8546 | 0.00000158685 | 90 | 8.0638681843048232e-10,-2.5202062658991053e-14,-2.347712701328275e-09 | 0.24923650088070803,0.044450000000049103,0.044450000066594914
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.042Z | Extended Element | 5333554.1746576531,2184676.9386489629,360.37082007344742 | 90.8546 | 0.00000158685 | 90 | 1.1707956271145292e-09,3.1974423109204508e-14,-2.7333745405977439e-09 | 0.24923650077673609,0.04445000000006516,0.044449998092547585
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.057Z | Extended Element | 5333554.3620971451,2184676.9414449111,360.30770772429378 | 90.8546 | 0.00000158685 | 90 | -3.4295469242273668e-10,4.8031023602845835e-14,-1.6492207703666661e-09 | 0.24923649902879538,0.04445000000013534,0.044450000765086845
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.072Z | Extended Element | 5333554.3619658034,2184676.941442946,360.37120758844014 | 90.8546 | 0.00000158685 | 90 | 1.6444699491025005e-09,1.048709730167019e-13,-8.4752635465257242e-10 | 0.24923650171879116,0.044450000000192183,0.04445000056099141
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.085Z | Extended Element | 5333554.460312089,2184676.9606538005,360.29834042065352 | -179.145 | -0.118524 | 90 | -3.4391843202835757e-10,3.701287094812499e-12,-2.469148126288372e-09 | 0.33972499994144822,0.12700000101613265,0.01270000465596844
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.095Z | Line | 5333546.7828949327,2184676.8588350415,360.34310939997295 | 0 | 0 | 0 | 0,0,0 | 14.12085737567395,0.21063373144716024,0.034571147472718167
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.106Z | Line | 5333554.2900167434,2184676.9708150025,360.42498876793024 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268418878316879,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.117Z | Line | 5333554.6966549,2184679.5082772579,360.41283767089959 | 0 | 0 | 0 | -0.85456250049173832,-2.4615843673236668,-0.052442697573781061 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.125Z | Line | 5333554.2903377432,2184677.2756537031,360.37419365646946 | 0 | 0 | 0 | 0,0,-0.02538978567582717 | 5.2516348659992218e-05,7.8417360782623291e-07,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.135Z | Line | 5333554.2603406813,2184679.2794990814,360.42447813623068 | 0 | 0 | 0 | 0,0,-0.02538978567582717 | 5.2515417337417603e-05,7.8417360782623291e-07,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.143Z | Line | 5333554.2681408143,2184677.2753229374,360.36145278689344 | 0 | 0 | 0 | 0,0,0 | 0.034919044002890587,0.00052053621038794518,7.2242519934206939e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.154Z | Line | 5333554.2679569339,2184677.2753201905,360.45035259668288 | 0 | 0 | 0 | 0,0,0 | 0.034919044002890587,0.00052053621038794518,7.2242518456278049e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.162Z | Line | 5333554.2683246955,2184677.2753256815,360.27255297708734 | 0 | 0 | 0 | 0,0,0 | 0.034919044002890587,0.00052053621038794518,7.2242518342591211e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.173Z | Line | 5333554.2379598757,2184679.2791653248,360.5006370764421 | 0 | 0 | 0 | 0,0,0 | 0.034919045865535736,0.00052053621038794518,7.2242520332110871e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.182Z | Line | 5333554.238143757,2184679.2791680703,360.41173726663453 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.224251839943463e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.192Z | Line | 5333554.2383276373,2184679.2791708163,360.32283745686863 | 0 | 0 | 0 | 0,0,0 | 0.034919044934213161,0.00052053621038794518,7.224251987736352e-05
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.202Z | Line | 5333554.2903641248,2184677.2756542186,360.3614987635346 | 0 | 0 | 0 | -0.029997311532497406,0,0 | 0,2.0038451300933957,0.050284479821925743
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.214Z | Extended Element | 5333554.1736494219,2184679.3188358247,360.60318479834672 | -89.1424 | -1.43709 | -89.8814 | 4.0594372272964797e-10,-3.2672460436718717e-09,1.2236441027102529e-10 | 2.0859791733468991,0.38099999999764872,0.085725000122392259
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.222Z | Line | 5333565.3776793908,2184689.4629498799,360.77852643815692 | 0 | 0 | 0 | 0,0,-0.9144016215548163 | 0.00061557535082101822,9.1814436018466949e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.233Z | Line | 5333564.5230937311,2184687.0013651666,360.82487729849038 | 0 | 0 | 0 | 0,0,-0.91440153679434388 | 0.00073069240897893906,1.0898802429437637e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.241Z | Line | 5333563.6685080715,2184684.5397804538,360.87111595120746 | 0 | 0 | 0 | 0,0,-0.914401437537947 | 0.00084580481052398682,1.2617092579603195e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.250Z | Line | 5333562.8139224108,2184682.0781957419,360.86829863597006 | 0 | 0 | 0 | 0,0,-0.91440132378818362 | 0.00096092093735933304,1.4333054423332214e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.260Z | Line | 5333561.9593367521,2184679.6166110304,360.8164253535075 | 0 | 0 | 0 | 0,0,-0.91440119554152943 | 0.00107603520154953,1.6050413250923157e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.268Z | Line | 5333561.1047510942,2184677.1550263194,360.76443986171211 | 0 | 0 | 0 | 0,0,-0.91440105280020134 | 0.0011911503970623016,1.7767306417226791e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.277Z | Line | 5333596.2607055893,2184689.9236164554,360.79932151983201 | 0 | 0 | 0 | 0,0,-0.91440162155458893 | 0.00061557535082101822,9.1823749244213104e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.287Z | Line | 5333596.4638833925,2184689.9266471569,360.79969795353952 | 0 | 0 | 0 | -0.00070640351623296738,-1.0537449270486832e-05,-0.914401555882705 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.297Z | Line | 5333595.6092977338,2184687.465062445,360.84996320328668 | 0 | 0 | 0 | -0.00059146806597709656,-8.8228844106197357e-06,-0.91440163746898406 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.306Z | Line | 5333595.4061199315,2184687.4620317444,360.84956115791078 | 0 | 0 | 0 | 0,0,-0.91440153679491232 | 0.00073069054633378983,1.0899733752012253e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.317Z | Line | 5333594.7547120741,2184685.0034777336,360.90011621056209 | 0 | 0 | 0 | -0.00047630723565816879,-7.1045942604541779e-06,-0.91440170472350246 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.324Z | Line | 5333594.5515342699,2184685.0004470325,360.89968858834999 | 0 | 0 | 0 | 0,0,-0.91440143753840175 | 0.00084580667316913605,1.2616626918315887e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.334Z | Line | 5333593.9001264144,2184682.5418930226,360.90121325894444 | 0 | 0 | 0 | -0.00036120135337114334,-5.3877010941505432e-06,-0.91440175744838825 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.343Z | Line | 5333593.6969486102,2184682.5388623206,360.90076005104333 | 0 | 0 | 0 | 0,0,-0.91440132378630778 | 0.00096092186868190765,1.4333520084619522e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.353Z | Line | 5333593.0455407538,2184680.0803083112,360.85325433766326 | 0 | 0 | 0 | -0.00024608056992292404,-3.6708079278469086e-06,-0.91440179568394342 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.361Z | Line | 5333592.8423629524,2184680.0772776087,360.85277554594711 | 0 | 0 | 0 | 0,0,-0.91440119554152943 | 0.0010760370641946793,1.6050878912210464e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.372Z | Line | 5333592.1909550941,2184677.6187235964,360.80518320892503 | 0 | 0 | 0 | -0.0001309690997004509,-1.9534491002559662e-06,-0.91440181942238041 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.382Z | Line | 5333591.9877772899,2184677.6156928954,360.80467883316697 | 0 | 0 | 0 | 0,0,-0.91440105279832551 | 0.0011911531910300255,1.7768237739801407e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.390Z | Line | 5333610.5847407673,2184690.1372808861,360.78878669997528 | 0 | 0 | 0 | -0.00070640631020069122,-1.0536983609199524e-05,-0.9144015558813976 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.401Z | Line | 5333609.7301551085,2184687.6756961765,360.840827290101 | 0 | 0 | 0 | -0.00059146806597709656,-8.822418749332428e-06,-0.91440163747034831 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.409Z | Line | 5333608.8755694451,2184685.2141114641,360.89275911093023 | 0 | 0 | 0 | -0.00047630537301301956,-7.1045942604541779e-06,-0.91440170472395721 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.420Z | Line | 5333608.0209837891,2184682.7525267536,360.89563409162037 | 0 | 0 | 0 | -0.00036120042204856873,-5.3877010941505432e-06,-0.91440175744833141 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.428Z | Line | 5333607.1663981304,2184680.2909420403,360.84945328835238 | 0 | 0 | 0 | -0.0002460842952132225,-3.6703422665596008e-06,-0.91440179568303392 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.438Z | Line | 5333606.3118124697,2184677.8293573279,360.80316025237596 | 0 | 0 | 0 | -0.0001309690997004509,-1.9534491002559662e-06,-0.91440181942220988 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.445Z | Line | 5333565.3791712904,2184689.3804127853,360.3913047425479 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196527138352,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.453Z | Line | 5333564.524634379,2184686.9188287994,360.43765563877463 | 0 | 0 | 0 | -0.002462443895637989,0,0 | 0,0.16508196573704481,1.1368683772161603e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.461Z | Line | 5333563.6700974666,2184684.4572448139,360.48389433352514 | 0 | 0 | 0 | -0.0024624448269605637,0,-1.3073986337985843e-12 | 0,0.16508196573704481,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.471Z | Line | 5333562.8155605542,2184681.9956608284,360.48107706645504 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196573704481,5.1159076974727213e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.482Z | Line | 5333561.9610236436,2184679.5340768439,360.4292038383025 | 0 | 0 | 0 | -0.0024624457582831383,0,0 | 0,0.1650819662027061,1.1368683772161603e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.491Z | Line | 5333561.1064867331,2184677.0724928607,360.37721840695326 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196573704481,2.2737367544323206e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.502Z | Line | 5333591.9895129297,2184677.5331594371,360.41745737840978 | 0 | 0 | 0 | -0.0024624448269605637,0,-3.4106051316484809e-13 | 0,0.16508196527138352,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.510Z | Line | 5333592.1921308553,2184677.5361817861,360.41796142952467 | 0 | 0 | 0 | -0.0024624448269605637,0,-1.1368683772161603e-13 | 0,0.1650819662027061,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.519Z | Line | 5333593.0466677686,2184679.9977657739,360.46603256831531 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196573704481,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.528Z | Line | 5333592.844049844,2184679.9947434235,360.46555403074257 | 0 | 0 | 0 | -0.0024624448269605637,0,-7.3896444519050419e-13 | 0,0.16508196527138352,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.537Z | Line | 5333593.9012046782,2184682.459349758,360.51399150578817 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196573704481,5.6843418860808015e-14
