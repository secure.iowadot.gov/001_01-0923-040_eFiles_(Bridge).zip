Properties of the parts of a building model (IFC4X3_ADD2), part 37 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.247Z | Extended Element | 5333611.0777536016,2184690.9781668237,361.92634132058254 | 0.855134 | 3.58092e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.273Z | Extended Element | 5333610.849178575,2184690.9747572853,361.92634132008703 | 0.855134 | -6.35598e-08 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.299Z | Extended Element | 5333610.6206035437,2184690.971347746,361.92634131988632 | 0.855134 | -6.3066e-08 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.323Z | Extended Element | 5333610.3920285162,2184690.967938208,361.92634131992463 | 0.855134 | 3.58092e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.348Z | Extended Element | 5333610.3807455786,2184691.0836702622,361.92016817841471 | -89.1454 | -180 | -1.0298e-07 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.373Z | Extended Element | 5333610.3822135692,2184690.9852562794,361.92016817825998 | -89.1454 | -180 | -1.02977e-07 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.399Z | Extended Element | 5333612.2771695722,2184691.0961503121,361.44443215898553 | 96.546 | 90.0133 | 4.1622e-07 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.425Z | Extended Element | 5333612.2782422174,2184691.0243078587,361.07996792273792 | 96.546 | 90.0132 | 4.1664e-07 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.449Z | Extended Element | 5333610.4444498708,2184690.9640166415,361.92849605964994 | 0.854638 | -0.000002073 | -101.012 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.472Z | Extended Element | 5333610.6726850681,2184690.9902066137,361.92849605955382 | 0.854638 | -0.00000207343 | -101.012 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.496Z | Extended Element | 5333610.9009202635,2184691.0163965891,361.92849606020337 | 0.854637 | -0.00000183232 | -101.012 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.505Z | Line | 5333549.2494233819,2184690.1908574193,361.88064484096469 | 0 | 0 | 0 | -0.31746531836688519,-0.0047354688867926598,-0.055121667835805965 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.514Z | Line | 5333612.8011637386,2184691.1388265779,360.17036755219425 | 0 | 0 | 0 | 0,0,0 | 9.3132257461547852e-10,0,1.7442250443979788
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.523Z | Line | 5333612.8026791019,2184691.037236698,360.17036755219425 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 9.3132257461547852e-10,0,1.7442250443979788
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.531Z | Line | 5333612.9154512519,2184691.1405313462,360.17036755219431 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,0 | 1.862645149230957e-09,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.540Z | Line | 5333612.9167927839,2184691.0505952542,360.17036755219442 | 0 | 0 | 0 | 0,0,0 | 9.3132257461547852e-10,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.549Z | Line | 5333613.0297387671,2184691.1422361145,360.17036755217237 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 9.3132257461547852e-10,0,1.7045374451603266
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.557Z | Line | 5333613.0306615839,2184691.0803706469,360.17036755216776 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,0 | 9.3132257461547852e-10,0,1.7045374451603266
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.566Z | Line | 5333613.1186290579,2184691.1435620454,360.17036755291605 | 0 | 0 | 0 | 0,0,0 | 9.3132257461547852e-10,0,1.6891033782067666
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.574Z | Line | 5333613.1192262061,2184691.1035292819,360.17036755217242 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 9.3132257461547852e-10,0,1.6891033782067666
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.600Z | Extended Element | 5333613.1186290579,2184691.1435620454,360.17036755291605 | -67.7256 | -1.22618e-08 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.624Z | Extended Element | 5333613.119226207,2184691.1035292828,360.17036755217248 | -67.7256 | -2.72296e-08 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.650Z | Extended Element | 5333613.029738768,2184691.1422361154,360.17036755217242 | -67.7256 | -5.90395e-08 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.675Z | Extended Element | 5333613.0306615848,2184691.0803706474,360.17036755216782 | -67.7256 | -5.90395e-08 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.702Z | Extended Element | 5333612.9154512528,2184691.1405313467,360.17036755219436 | -67.7256 | -5.3345e-08 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.725Z | Extended Element | 5333612.9167927848,2184691.0505952546,360.17036755219442 | -67.7256 | -1.2011e-08 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.750Z | Extended Element | 5333612.8011637386,2184691.1388265784,360.17036755219425 | -67.7256 | -1.18743e-08 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.779Z | Extended Element | 5333612.802679101,2184691.037236698,360.17036755219425 | -67.7256 | -2.6369e-08 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.803Z | Extended Element | 5333610.4310618322,2184690.79717685,360.43497027973774 | -179.145 | -2.5812e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.826Z | Extended Element | 5333610.6592970295,2184690.8233668217,360.4349702795883 | -179.145 | -2.57478e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.853Z | Extended Element | 5333610.8875322277,2184690.849556799,360.43497028078173 | -179.145 | -1.71438e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.879Z | Extended Element | 5333611.115767424,2184690.8757467745,360.43497028078292 | -179.145 | -2.57478e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.903Z | Extended Element | 5333611.3440026203,2184690.901936749,360.43497028130048 | -179.145 | -2.56836e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.925Z | Extended Element | 5333611.5722378222,2184690.928126723,360.43497028262885 | -179.145 | -2.56836e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.092Z | Complex Chain | 5333546.9734283434,2184676.1107046725,361.86815988000063 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000050263 | 0.0019901683554053307,1.9889653257720852e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.101Z | Complex Chain | 5333546.7448533149,2184676.1072951346,361.86815987828231 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000919967 | 0.0019901674859174705,1.5233040384643459e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.110Z | Complex Chain | 5333546.5162782846,2184676.1038855948,361.86815987680279 | 0 | 0 | 0 | 0,-0.13333514798432589,-0.85407499995309522 | 0.0019901684170684185,2.9202904122671569e-09,8.7140961113618687e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.120Z | Complex Chain | 5333546.287703258,2184676.1004760563,361.86815987561812 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000550485 | 0.001990167424082756,1.5233040384643459e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.131Z | Complex Chain | 5333546.0591282276,2184676.0970665175,361.86815987343437 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000431114 | 0.0019901683554053307,1.5233037886641654e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.139Z | Complex Chain | 5333545.8305531982,2184676.0936569781,361.86815987231313 | 0 | 0 | 0 | 0,-0.13333514891564846,-0.85407499998805392 | 0.0019901665546078794,1.9889650759719046e-09,1.460875864722766e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.149Z | Complex Chain | 5333545.6019781688,2184676.0902474406,361.86815987000938 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500001386083 | 0.0019901674859174705,1.0576427511566067e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.157Z | Complex Chain | 5333545.3734031413,2184676.0868379017,361.8681598689414 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000601644 | 0.001990167424082756,1.9889650759719046e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.167Z | Complex Chain | 5333545.1448281119,2184676.0834283633,361.86815986753373 | 0 | 0 | 0 | 0,-0.13333514891564846,-0.85407500000851755 | 0.0019901684172530542,1.5233037886641654e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.175Z | Complex Chain | 5333544.9924447574,2184676.0811553374,361.86815986593672 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000050263 | 0.0019901674859434766,2.4546261689906146e-09,5.6843418860808015e-14
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.184Z | Complex Chain | 5333544.8400614038,2184676.0788823115,361.86815986459112 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000249215 | 0.0019901674859174705,1.9889653257720852e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.194Z | Complex Chain | 5333544.6876780484,2184676.0766092851,361.8681598638417 | 0 | 0 | 0 | 0,-0.13333514891564846,-0.85407500000510694 | 0.0019901684172530542,1.9889650759719046e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.203Z | Complex Chain | 5333544.578128837,2184676.0765628712,361.85916722365954 | 0 | 0 | 0 | 0,-0.13650979474186897,-0.42386249999721698 | 0.0020375489980535488,0,1.4495071809506044e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.214Z | Complex Chain | 5333544.4638413209,2184676.0748581025,361.8393234223247 | 0 | 0 | 0 | 0,-0.1365097954007182,-0.41116359562672156 | 0.0020375606560780902,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.222Z | Complex Chain | 5333544.3495538076,2184676.0731533323,361.8194796215783 | 0 | 0 | 0 | 0,-0.13650979399330926,-0.39846363803544116 | 0.0020375608522424926,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.232Z | Complex Chain | 5333544.2606635178,2184676.0718274019,361.80404555385371 | 0 | 0 | 0 | 0,-0.13650979474186897,-0.38576368331236593 | 0.0020375587046146393,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.240Z | Complex Chain | 5333546.9832432885,2184676.0933866003,361.86198673837885 | 0 | 0 | 0 | -2.7623086608946323,-0.041205355897545815,-0.069515861970558035 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.251Z | Complex Chain | 5333546.9847112801,2184675.9949726174,361.86198673837879 | 0 | 0 | 0 | -2.7623086608946323,-0.041205355897545815,-0.069515861970501192 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.259Z | Line | 5333545.0882872893,2184675.9824925694,361.38625070503628 | 0 | 0 | 0 | 0,0,0 | 1.892584253102541,0.21717356611043215,1.4226259281713283e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.268Z | Line | 5333545.0872146459,2184676.0543350233,361.02178646890167 | 0 | 0 | 0 | 0,0,0 | 1.8925842540338635,0.21717356517910957,1.4226259281713283e-08
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.278Z | Complex Chain | 5333546.9543804424,2184676.1104205442,360.11954708642901 | 0 | 0 | 0 | -8.8853381154455069e-09,-0.13333515297675042,0 | 0.0019901618361473083,0,1.301219210066346
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.287Z | Complex Chain | 5333546.725805412,2184676.1070110057,360.11954708478549 | 0 | 0 | 0 | -7.0226929662145499e-09,-0.1333351534424117,0 | 0.001990162767469883,0,1.3012192100483835
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.297Z | Complex Chain | 5333546.4972303845,2184676.1036014669,360.11954708314204 | 0 | 0 | 0 | -7.4505805969238281e-09,-0.13333515064844914,0 | 0.001990162767469883,0,1.3012192101281348
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.306Z | Complex Chain | 5333546.2686553542,2184676.1001919284,360.11954708149847 | 0 | 0 | 0 | -8.8853381154455069e-09,-0.1333351534424117,0 | 0.0019901618361473083,0,1.3012192100603206
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.316Z | Complex Chain | 5333546.0400803247,2184676.0967823896,360.11954707985501 | 0 | 0 | 0 | -7.9536622383732936e-09,-0.13333515157977166,0 | 0.0019901618361473083,0,1.3012192101329096
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.325Z | Complex Chain | 5333545.8115052953,2184676.0933728507,360.1195470782115 | 0 | 0 | 0 | -7.4505805969238281e-09,-0.13333515297675036,0 | 0.0019901636987924576,0,1.3012192100573079
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.336Z | Complex Chain | 5333545.582930265,2184676.0899633123,360.11954707656798 | 0 | 0 | 0 | -8.8853381143613047e-09,-0.13333515251108907,0 | 0.0019901618361473083,0,1.3012192100539541
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.345Z | Complex Chain | 5333545.3543552347,2184676.0865537734,360.11954707492453 | 0 | 0 | 0 | -7.4505805969238281e-09,-0.13333515251108902,0 | 0.0019901636987924576,0,1.3012192100545794
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.356Z | Complex Chain | 5333545.1257802071,2184676.083144235,360.11954707328101 | 0 | 0 | 0 | -7.9540155393121453e-09,-0.1333351529767503,0 | 0.001990162767469883,0,1.3012192100585585
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.365Z | Complex Chain | 5333544.9733968517,2184676.080871209,360.1195470721853 | 0 | 0 | 0 | -7.4505805969238281e-09,-0.13333515251108902,0 | 0.0019901636987924576,0,1.3012192100577626
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.374Z | Complex Chain | 5333544.8210134963,2184676.0785981831,360.1195470710897 | 0 | 0 | 0 | -7.9540155388784645e-09,-0.13333515344241159,0 | 0.001990162767469883,0,1.3012192100639586
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.383Z | Complex Chain | 5333544.6686301427,2184676.0763251572,360.11954706999398 | 0 | 0 | 0 | -7.9540155382279432e-09,-0.13333515297675025,0 | 0.0019901618361473083,0,1.3012192100666871
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.391Z | Complex Chain | 5333546.9210069869,2184676.1146262386,361.87031461930047 | 0 | 0 | 0 | -0.0022889378127716907,0,-0.85159357427911841 | 0,0.15344360337056936,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.401Z | Complex Chain | 5333546.6927717905,2184676.0884362659,361.87031461743487 | 0 | 0 | 0 | -0.0022889378127716907,0,-0.85159357427906157 | 0,0.15344360383623065,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.410Z | Complex Chain | 5333546.4645365933,2184676.0622462914,361.87031461648218 | 0 | 0 | 0 | -0.0022889387440942653,0,-0.85159357427911841 | 0,0.15344360383623065,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.424Z | Complex Chain | 5333546.9343950376,2184676.2814660324,360.37678883981522 | 0 | 0 | 0 | -1.862645149230957e-09,-0.16331763351734124,0 | 0.0024362326369285186,0,0.95426667038824742
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.434Z | Complex Chain | 5333546.7061598394,2184676.2552760602,360.37678883794968 | 0 | 0 | 0 | -1.862645149230957e-09,-0.16331763351734124,0 | 0.0024362326369285186,0,0.95426667038824742
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.443Z | Complex Chain | 5333546.4779246412,2184676.2290860834,360.37678883742706 | 0 | 0 | 0 | -1.862645149230957e-09,-0.16331763444866382,0 | 0.0024362326369285186,0,0.95426667038824742
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.452Z | Complex Chain | 5333546.249689443,2184676.2028961079,360.37678883571226 | 0 | 0 | 0 | -1.862645149230957e-09,-0.16331763305167996,0 | 0.0024362335682510932,0,0.95426667038824742
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.463Z | Complex Chain | 5333546.0214542486,2184676.1767061334,360.37678883451389 | 0 | 0 | 0 | -1.862645149230957e-09,-0.16331763398300253,0 | 0.002436231705605944,0,0.95426667038824742
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.471Z | Complex Chain | 5333545.7932190467,2184676.1505161589,360.37678883412616 | 0 | 0 | 0 | -1.862645149230957e-09,-0.16331763351734124,0 | 0.002436231705605944,0,0.95426667038819057
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.480Z | Line | 5333544.5642931322,2184675.9398163045,360.11218609433473 | 0 | 0 | 0 | -1.3969838619232178e-08,-2.7939677238464355e-09,0 | 0,0,1.7442250443979788
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.488Z | Line | 5333544.5627777688,2184676.0414061844,360.11218609449452 | 0 | 0 | 0 | -1.3969838619232178e-08,-2.3283064365386963e-09,0 | 0,0,1.7442250443979788
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.498Z | Line | 5333544.4500056189,2184675.9381115362,360.1121860934947 | 0 | 0 | 0 | -1.4901161193847656e-08,-1.862645149230957e-09,0 | 0,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.517Z | Line | 5333544.4486640869,2184676.0280476287,360.1121860936363 | 0 | 0 | 0 | -1.3969838619232178e-08,-2.7939677238464355e-09,0 | 0,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.526Z | Line | 5333544.3357181037,2184675.9364067684,360.11218609263273 | 0 | 0 | 0 | -1.3969838619232178e-08,-2.3283064365386963e-09,0 | 0,0,1.7045374451602697
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.535Z | Line | 5333544.3347952869,2184675.9982722355,360.11218609272544 | 0 | 0 | 0 | -1.3969838619232178e-08,-1.862645149230957e-09,0 | 0,0,1.7045374451602697
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.546Z | Line | 5333544.2468278138,2184675.935080837,360.11218609272299 | 0 | 0 | 0 | -1.3969838619232178e-08,-2.7939677238464355e-09,0 | 0,0,1.6891033782067097
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.555Z | Line | 5333544.2462306647,2184675.9751136005,360.11218609204235 | 0 | 0 | 0 | -1.3969838619232178e-08,-2.3283064365386963e-09,0 | 0,0,1.6891033782067097
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.581Z | Extended Element | 5333544.2627010755,2184675.9353176071,361.80404318776516 | 0.855138 | 2.17427e-07 | -89.9982 | -0.013383672314236547,-2.5083639676360559e-07,-0.013393705419718058 | 0.013383672646049663,0.39914714553692082,0.14989860043402853
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.606Z | Extended Element | 5333544.3515913663,2184675.936643539,361.81947734623293 | 0.855138 | 6.5767e-07 | -89.9983 | -0.013383671999201482,-2.4193799773950873e-07,-0.013393736390429629 | 0.01338367305430911,0.4118471145939836,0.149898569833153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.632Z | Extended Element | 5333544.4658788787,2184675.9383483091,361.839321231393 | 0.855139 | 4.16207e-07 | -89.9983 | -0.013383673838384916,-2.3365829091511947e-07,-0.013393766319802344 | 0.013383672722568426,0.42454708563157617,0.14989854031566802
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.657Z | Extended Element | 5333544.5801663846,2184675.9400530769,361.85916722367409 | 0.855133 | 1.41278e-09 | -89.9985 | -0.013383665148291524,-2.0613436121344486e-07,-0.013392900089961343 | 0.013383665484346984,0.43724793801004758,0.14989939992524939
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.683Z | Extended Element | 5333544.6876780493,2184676.0766092855,361.86815986384175 | -179.145 | -3.95322e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.708Z | Extended Element | 5333544.8400614038,2184676.0788823115,361.86815986459112 | -179.145 | -4.6196e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.734Z | Extended Element | 5333544.9924447574,2184676.0811553369,361.86815986593672 | -179.145 | -3.96317e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.758Z | Extended Element | 5333545.1448281128,2184676.0834283633,361.86815986753373 | -179.145 | -3.95322e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.782Z | Extended Element | 5333545.3734031422,2184676.0868379022,361.8681598689414 | -179.145 | -3.95313e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.806Z | Extended Element | 5333545.6019781707,2184676.0902474411,361.86815987000949 | -179.145 | -3.28675e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.832Z | Extended Element | 5333545.8305531992,2184676.0936569786,361.86815987231324 | -179.145 | -3.95313e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.857Z | Extended Element | 5333546.0591282267,2184676.0970665179,361.86815987343442 | -179.145 | -4.61458e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.883Z | Extended Element | 5333546.287703258,2184676.1004760563,361.86815987561812 | -179.145 | -3.95314e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.909Z | Extended Element | 5333546.5162782855,2184676.1038855943,361.86815987680279 | -179.145 | -3.96309e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.936Z | Extended Element | 5333546.7448533159,2184676.1072951355,361.86815987828237 | -179.145 | -4.61475e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.961Z | Extended Element | 5333546.9734283453,2184676.1107046725,361.86815988000058 | -179.145 | -3.95313e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:59.987Z | Extended Element | 5333546.9832432894,2184676.0933866003,361.86198673837885 | -89.1454 | 1.36738e-07 | -180 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.015Z | Extended Element | 5333546.9847112792,2184675.9949726178,361.86198673837879 | -89.1454 | -7.70703e-07 | -180 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.047Z | Extended Element | 5333545.0882872874,2184675.9824925694,361.38625070503622 | -83.4558 | -90.0133 | -0.00185007 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.084Z | Extended Element | 5333545.0872146469,2184676.0543350233,361.02178646890178 | -83.4558 | -90.0132 | -0.00185194 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.116Z | Extended Element | 5333546.9210069878,2184676.1146262386,361.87031461932611 | 0.854638 | -180 | 78.9882 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.144Z | Extended Element | 5333546.6927717905,2184676.0884362659,361.87031461745295 | 0.854638 | -180 | 78.9882 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.171Z | Extended Element | 5333546.4645365933,2184676.0622462919,361.87031461642812 | 0.854637 | -180 | 78.9882 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.197Z | Extended Element | 5333546.9343950367,2184676.2814660319,360.37678883981528 | 0.854625 | 1.73363e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.221Z | Extended Element | 5333546.7061598385,2184676.2552760602,360.37678883794968 | 0.854625 | 1.74647e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.251Z | Extended Element | 5333546.4779246422,2184676.2290860834,360.37678883742711 | 0.854624 | 8.79651e-08 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.275Z | Extended Element | 5333546.249689443,2184676.2028961079,360.3767888357122 | 0.854625 | 1.74005e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.301Z | Extended Element | 5333546.0214542495,2184676.1767061339,360.37678883451389 | 0.854624 | 1.74005e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.327Z | Extended Element | 5333545.7932190467,2184676.1505161589,360.37678883412616 | 0.854625 | 1.74005e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.354Z | Extended Element | 5333546.9543804424,2184676.1104205446,360.11954708642907 | 0.856182 | -0.0000562365 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.378Z | Extended Element | 5333546.7258054139,2184676.1070110062,360.11954708478555 | 0.856182 | -0.0000562797 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.400Z | Extended Element | 5333546.4972303845,2184676.1036014669,360.11954708314209 | 0.856182 | -0.0000563246 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.427Z | Extended Element | 5333546.2686553542,2184676.1001919289,360.11954708149841 | 0.856182 | -0.0000561939 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.453Z | Extended Element | 5333546.0400803238,2184676.09678239,360.11954707985512 | 0.856181 | -0.000056281 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.479Z | Extended Element | 5333545.8115052972,2184676.0933728507,360.11954707821155 | 0.856181 | -0.0000562797 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.504Z | Extended Element | 5333545.5829302659,2184676.0899633127,360.1195470765681 | 0.856182 | -0.0000562374 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.530Z | Extended Element | 5333545.3543552356,2184676.0865537734,360.11954707492464 | 0.856181 | -0.00005628 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.556Z | Extended Element | 5333545.1257802071,2184676.083144235,360.11954707328101 | 0.856182 | -0.00005628 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.582Z | Extended Element | 5333544.9733968526,2184676.080871209,360.11954707218536 | 0.856182 | -0.000056323 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.607Z | Extended Element | 5333544.8210134972,2184676.0785981836,360.11954707108976 | 0.856181 | -0.0000562368 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.633Z | Extended Element | 5333544.6686301436,2184676.0763251577,360.1195470699941 | 0.856181 | -0.0000562794 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.657Z | Extended Element | 5333544.2462306647,2184675.975113601,360.11218609204235 | -67.7255 | 1.0909e-07 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.682Z | Extended Element | 5333544.3347952878,2184675.9982722355,360.11218609272549 | -67.7255 | 1.0571e-07 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.705Z | Extended Element | 5333544.4486640887,2184676.0280476296,360.11218609363641 | -67.7255 | 7.75347e-08 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.731Z | Extended Element | 5333544.5627777688,2184676.0414061849,360.11218609449452 | -67.7255 | 9.37677e-08 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.755Z | Extended Element | 5333544.2468278147,2184675.9350808375,360.11218609272305 | -67.7255 | 9.41218e-08 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.781Z | Extended Element | 5333544.3357181046,2184675.9364067689,360.11218609263267 | -67.7255 | 7.60452e-08 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.809Z | Extended Element | 5333544.4500056179,2184675.9381115357,360.11218609349464 | -67.7255 | 1.3353e-07 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.836Z | Extended Element | 5333544.5642931322,2184675.9398163049,360.11218609433479 | -67.7255 | 7.92729e-08 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.844Z | Complex Chain | 5333613.1407038849,2184691.1518330202,361.79316792452374 | 0 | 0 | 0 | -2.758490270934999,-0.16657648282125592,-1.8684431779547594e-10 | 0.0010480530707154684,0,2.5585222829249687e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.857Z | Complex Chain | 5333613.1407038849,2184691.1518330206,361.69791773402335 | 0 | 0 | 0 | -2.758490270934999,-0.16657648282125592,-1.8684431779547594e-10 | 0.0010480530707154684,0,2.5589573783647376e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.867Z | Complex Chain | 5333613.1407038849,2184691.1518330211,361.60266754352295 | 0 | 0 | 0 | -2.758490270934999,-0.16657648282125592,-1.8684431779547594e-10 | 0.0010480530707154684,0,2.5590907171135768e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.876Z | Complex Chain | 5333610.3834951771,2184690.9852756565,361.39946713693558 | 0 | 0 | 0 | 0,0,0 | 2.7641283674165606,0.10791644221171737,4.4349235395202413e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.886Z | Complex Chain | 5333610.3834951771,2184690.9852756569,361.27246688293508 | 0 | 0 | 0 | 0,0,0 | 2.7641283674165606,0.10791644221171737,4.4349235395202413e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.895Z | Complex Chain | 5333610.3834900688,2184690.985275581,361.14546662893457 | 0 | 0 | 0 | 0,0,0 | 2.7641283692792058,0.10791644174605608,4.4354919737088494e-10
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.921Z | Extended Element | 5333610.3822136139,2184690.9852565383,361.79316792433696 | -84.6507 | 90 | -4.49468 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.948Z | Extended Element | 5333610.3822136139,2184690.9852565387,361.69791773383656 | -84.6511 | 90 | -4.49425 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.973Z | Extended Element | 5333610.3822136139,2184690.9852565387,361.60266754333611 | -84.6511 | 90 | -4.49425 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:00.999Z | Extended Element | 5333610.3834951771,2184690.9852756569,361.39946713693564 | 0.196302 | 90 | -89.3417 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.026Z | Extended Element | 5333610.3834951771,2184690.9852756578,361.27246688293513 | 0.508097 | 90 | -89.6535 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.049Z | Extended Element | 5333610.3834900688,2184690.9852755815,361.14546662893457 | 0.162467 | 90 | -89.3078 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.058Z | Line | 5333610.3807455227,2184691.0836705184,361.79316792433679 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294694412499666,3.2719071896281093e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.068Z | Line | 5333610.3807455227,2184691.0836705184,361.69791773383639 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294694412499666,3.2719071896281093e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.076Z | Line | 5333610.3807455227,2184691.0836705184,361.602667543336 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294694412499666,3.2719071896281093e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.086Z | Line | 5333610.3807455227,2184691.0836705184,361.39946713693524 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294694412499666,3.2713387554395013e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.094Z | Line | 5333610.3807455227,2184691.0836705184,361.27246688293474 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294694412499666,3.2719071896281093e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.104Z | Line | 5333610.3807455227,2184691.0836705184,361.14546662893423 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294694412499666,3.2719071896281093e-10
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.130Z | Extended Element | 5333610.3807455236,2184691.0836705188,361.79316792433684 | -89.1454 | -90.0098 | -0.0000394007 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.156Z | Extended Element | 5333610.3807455236,2184691.0836705188,361.69791773383633 | -89.1454 | -90.0098 | -0.000039404 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.183Z | Extended Element | 5333610.3807455236,2184691.0836705188,361.60266754333605 | -89.1454 | -90.0098 | -0.0000394074 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.208Z | Extended Element | 5333610.3807455245,2184691.0836705193,361.3994671369353 | -89.1454 | -90.0098 | -0.0000394295 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.233Z | Extended Element | 5333610.3807455245,2184691.0836705188,361.27246688293491 | -89.1454 | -90.0098 | -0.0000394504 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.258Z | Extended Element | 5333610.3807455245,2184691.0836705188,361.14546662893429 | -89.1454 | -90.0098 | -0.0000394643 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.268Z | Line | 5333546.9847113313,2184675.9949723622,361.73498648465022 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693946838379,-9.7747943073045462e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.276Z | Line | 5333546.9847113313,2184675.9949723626,361.63973629414988 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693946838379,-9.7753627414931543e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.287Z | Line | 5333546.9847113313,2184675.9949723626,361.54448610364949 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693946838379,-9.7753627414931543e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.295Z | Line | 5333546.9847113313,2184675.9949723631,361.34128569724868 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693946838379,-9.7753627414931543e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.306Z | Line | 5333546.9847113313,2184675.9949723631,361.21428544324817 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693946838379,-9.7747943073045462e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.315Z | Line | 5333546.9847113313,2184675.9949723636,361.08728518924772 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693946838379,-9.7753627414931543e-10 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.324Z | Complex Chain | 5333546.9819616769,2184676.0933672246,361.21428544340273 | 0 | 0 | 0 | -2.7641283674165606,-0.10791644221171737,-9.645759746490512e-10 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.334Z | Complex Chain | 5333546.9819616769,2184676.093367225,361.34128569740324 | 0 | 0 | 0 | -2.7641283674165606,-0.10791644221171737,-9.645759746490512e-10 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.342Z | Complex Chain | 5333546.9819667852,2184676.0933673009,361.08728518940222 | 0 | 0 | 0 | -2.7641283692792058,-0.10791644174605608,-9.645759746490512e-10 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.349Z | Complex Chain | 5333544.22475297,2184675.9268098599,361.54448610249301 | 0 | 0 | 0 | -0.0010480540020380361,0,0 | 2.7584902700036764,0.16657648328691721,1.3113776731188409e-09
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.357Z | Complex Chain | 5333544.22475297,2184675.9268098604,361.6397362929934 | 0 | 0 | 0 | -0.0010480540020380361,0,0 | 2.7584902700036764,0.16657648328691721,1.3113208296999801e-09
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.367Z | Complex Chain | 5333544.22475297,2184675.9268098604,361.73498648349374 | 0 | 0 | 0 | -0.0010480540020380361,0,0 | 2.7584902700036764,0.16657648328691721,1.3113776731188409e-09
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.391Z | Extended Element | 5333546.9832432419,2184676.0933863441,361.73498648480512 | 85.9372 | 90 | 4.91744 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.417Z | Extended Element | 5333546.9832432419,2184676.0933863441,361.63973629430478 | 85.9363 | 90 | 4.9184 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.439Z | Extended Element | 5333546.9832432419,2184676.0933863437,361.54448610380445 | 85.9363 | 90 | 4.9184 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.462Z | Extended Element | 5333546.9819616769,2184676.093367225,361.34128569740324 | 79.6785 | 90 | 11.1762 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.488Z | Extended Element | 5333546.9819616778,2184676.093367225,361.21428544340284 | 79.677 | 90 | 11.1777 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.515Z | Extended Element | 5333546.9819667852,2184676.0933673009,361.08728518940222 | 79.6709 | 90 | 11.1837 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.541Z | Extended Element | 5333546.9847113332,2184675.994972364,361.08728518924778 | 90.8545 | 90.0098 | 0.00011792 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.566Z | Extended Element | 5333546.9847113322,2184675.994972364,361.21428544324829 | 90.8545 | 90.0098 | 0.000117886 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.591Z | Extended Element | 5333546.9847113332,2184675.994972364,361.34128569724879 | 90.8545 | 90.0098 | 0.000117844 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.618Z | Extended Element | 5333546.9847113322,2184675.9949723626,361.54448610364949 | 90.8545 | 90.0098 | 0.000117778 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.643Z | Extended Element | 5333546.9847113332,2184675.9949723631,361.63973629415 | 90.8545 | 90.0098 | 0.000117747 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.669Z | Extended Element | 5333546.9847113322,2184675.9949723622,361.73498648465011 | 90.8545 | 90.0098 | 0.000117709 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.678Z | Complex Chain | 5333610.3948284397,2184690.7726655309,360.89223606229893 | 0 | 0 | 0 | -0.0054018979745167773,-9.3132257461547852e-10,-0.05526269324070654 | 9.3132257461547852e-10,0.36191163072108762,0.09525007729434401
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.688Z | Complex Chain | 5333610.3894276908,2184691.1345771817,360.57180595650505 | 0 | 0 | 0 | -1.3401838486627043e-09,-0.36191163211576716,-0.055262696470151695 | 0.0054018990602134878,0,0.095250073855544654
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.698Z | Line | 5333613.1277490417,2184690.8515662136,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.707Z | Line | 5333612.844751386,2184690.8473448809,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,5.5879354476928711e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.717Z | Line | 5333612.2787560746,2184690.8389022136,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.727Z | Line | 5333611.995758418,2184690.83468088,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.737Z | Line | 5333611.7127607623,2184690.8304595463,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.745Z | Line | 5333611.4297631066,2184690.8262382126,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.755Z | Line | 5333611.1467654509,2184690.8220168795,360.96513011244809 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.765Z | Line | 5333613.122824165,2184691.1817291793,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.774Z | Line | 5333612.8398265094,2184691.1775078466,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.784Z | Line | 5333612.5568288537,2184691.173286513,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.792Z | Line | 5333612.2738311971,2184691.1690651793,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.802Z | Line | 5333611.9908335414,2184691.1648438456,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.810Z | Line | 5333611.7078358857,2184691.160622512,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.822Z | Line | 5333611.42483823,2184691.1564011788,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.829Z | Line | 5333611.1418405743,2184691.1521798451,360.96513011325266 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,6.0535967350006104e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.838Z | Line | 5333613.1534067169,2184690.8344844594,360.93973006143716 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.850Z | Line | 5333613.1534067169,2184690.8344844612,360.61929995384253 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.858Z | Line | 5333613.1534067169,2184690.8344844626,360.2988698462479 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.867Z | Line | 5333613.1534067169,2184690.8344844645,359.97843973865332 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.876Z | Line | 5333613.1533593619,2184690.8376591178,359.77523933226252 | 0 | 0 | 0 | -2.0317780403420329,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.886Z | Line | 5333613.1534067169,2184690.8344844659,359.67363912905211 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.894Z | Line | 5333613.1534067169,2184690.834484465,359.1871265563239 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.904Z | Line | 5333613.1534067169,2184690.8344844673,359.43038284267158 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.913Z | Line | 5333613.1484818421,2184691.1646474311,359.18712655736368 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.921Z | Line | 5333613.1484818421,2184691.1646474334,359.43038284371141 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.928Z | Line | 5333613.1484818421,2184691.164647432,359.67363913009189 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.937Z | Line | 5333613.1484818421,2184691.1646474306,359.9784397396931 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.945Z | Line | 5333613.1484818421,2184691.1646474288,360.29886984728773 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.955Z | Line | 5333613.1484818421,2184691.1646474274,360.61929995488237 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.965Z | Line | 5333613.1484818421,2184691.1646474255,360.93973006247694 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,0 | 0,0,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.974Z | Line | 5333612.0867232475,2184690.8185732784,360.95560509337645 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.983Z | Line | 5333612.0867232475,2184690.8185732793,360.63517498562527 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:01.992Z | Line | 5333612.0867232475,2184690.8185732807,360.31474487826307 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.002Z | Line | 5333612.0867232475,2184690.8185732816,359.99431477065008 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.017Z | Line | 5333612.0867232475,2184690.8185732826,359.68951416108655 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.024Z | Line | 5333612.0867232475,2184690.8185732835,359.44625787448189 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.035Z | Line | 5333612.0867232475,2184690.818573284,359.20300158842281 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.043Z | Line | 5333612.0820370261,2184691.1327370084,360.95560509437371 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.053Z | Line | 5333612.0820370261,2184691.1327370093,360.63517498682018 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.061Z | Line | 5333612.0817983728,2184691.1487362473,360.31474487895218 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:02.071Z | Line | 5333612.0817983728,2184691.1487362483,359.99431477166286 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,0 | 0,0,1.6336798580596223e-10
