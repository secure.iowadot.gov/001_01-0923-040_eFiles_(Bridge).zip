Properties of the parts of a building model (IFC4X3_ADD2), part 3 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.755Z | Smart Solid | 5333592.706847853,2184690.0712014223,336.89262382524765 | 0 | 0 | 0 | -1.552057284108737,-2.9058094996266353,-12.663141563128107 | 1.5520678541224371,2.9057937707255421,12.663154447390719 | Feature - Feature Definition: No Feature Definition; Feature Name: P15; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P15; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167595 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1063.94 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: -9.462 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 45 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P15; Top X: 17498633 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: -9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1063.94 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498633 us survey foot; Top Y: 7167595 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 45 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.818Z | Smart Solid | 5333591.6513995426,2184687.0309982221,336.71879603759209 | 0 | 0 | 0 | -2.1724836830708849,-0.86183349928290154,-12.798650974984373 | 2.1724748392988706,0.86185226313849728,12.798632044550004 | Feature - Feature Definition: No Feature Definition; Feature Name: P16; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P16; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167592 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P16; Top X: 17498632 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498632 us survey foot; Top Y: 7167592 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.885Z | Smart Solid | 5333591.2848463291,2184685.9752298705,336.71879603759209 | 0 | 0 | 0 | -2.1724668279949295,-0.86185198929563667,-12.79865097504258 | 2.172491694374826,0.86183377312576215,12.798632044491796 | Feature - Feature Definition: No Feature Definition; Feature Name: P17; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P17; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167588 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P17; Top X: 17498631 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498631 us survey foot; Top Y: 7167588 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.952Z | Smart Solid | 5333592.9300838197,2184684.221010922,336.54256032512063 | 0 | 0 | 0 | -0.16233224700742421,-0.16398599405145986,-12.95404114808224 | 0.16234849897059569,0.16398434992879629,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P18; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P18; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167585 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P18; Top X: 17498629 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498629 us survey foot; Top Y: 7167585 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:55.017Z | Smart Solid | 5333592.5635610865,2184683.1652273303,336.54256032512063 | 0 | 0 | 0 | -0.16234587132536826,-0.16398924390158398,-12.95404114808224 | 0.16233487465265165,0.16398110007867217,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P19; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P19; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167581 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P19; Top X: 17498628 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498628 us survey foot; Top Y: 7167581 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:55.087Z | Smart Solid | 5333592.197007874,2184682.1094284989,336.54256032512063 | 0 | 0 | 0 | -0.16232901718073545,-0.16397725405475838,-12.95404114808224 | 0.16235172879728446,0.16399308992549777,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P20; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P20; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167578 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P20; Top X: 17498627 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498627 us survey foot; Top Y: 7167578 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:55.150Z | Smart Solid | 5333589.1297840998,2184679.7676758952,336.89262382524765 | 0 | 0 | 0 | -2.9266842566026909,-1.5182135117069975,-12.663141563186421 | 2.9266994012197225,1.5182102950503604,12.663154447332408 | Feature - Feature Definition: No Feature Definition; Feature Name: P21; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P21; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167574 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1063.94 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 9.462 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: -45 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P21; Top X: 17498626 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1063.94 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498626 us survey foot; Top Y: 7167574 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: -45 deg
Civil Custom Graphics | [CivilDesignerProductsDynamic].[Supports\Pier\Pier_steel_piles] | Feature - Feature Definition: Pier_steel_piles; Feature Name: Pier2; Material - Footing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Concrete Pad Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Cap Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Column Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Pile Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); [CivilDesignerProductsDynamic].[Supports\Pier\Pier_steel_piles] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.048Z; User Label: Civil Custom Graphics; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; Pier - Name: Pier2; Template Name: IA Filleted Column Tee; Substructure Placement Rule - Elevation Constraints: SELECT to Edit; Horizontal Offset: 0 us survey foot; Apply Skew To Solids: no; Substructure Template: IA Filleted Column Tee; Conform BackWall With Deck Top: no; Orientation: 1; Conform Notch With Approach Slab: no; Integral: no; Conform Corbel With Approach Slab Bottom: no; Conform Corbel Bottom With Approach Slab: no; Pier properties - ItemTypes - Pile material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Name: Pier2; Template name: IA Filleted Column Tee; Cap material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Footing material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Column material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Cap build order: 1; Column build order: 1; Pile build order: 1; Footing build order: 1; Build Order - Pile Build Order: 1; Pier Cap Build Order: 1; Footing Build Order: 1; Column Build Order: 1; Concrete Pad Build Order: 1
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.189Z | Line | 5333549.606917914,2184683.1056121401,361.10726275768337 | 0 | 0 | 0 | -0.00029138661921024323,-0.00029138708487153053,-0.00058277289366515106 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.203Z | Line | 5333544.1221448043,2184668.7012898698,0 | 0 | 0 | 0 | 0,0,0 | 9.9964261269196868,28.79412899678573,0
Abut1: 169+36.0000 70.8546° | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:10:57.341Z; User Label: Abut1: 169+36.0000 70.8546°; Origin: 5333554.7745044045,2184699.3847974096,0; Yaw: -109.145; Pitch: 0; Roll: 0; Bounding Box Low: -0.015913751907646656,-0.0036657747347262687,0; Bounding Box High: 0.015913750510662794,0.0036657768768391576,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.349Z | Line | 5333558.1414132761,2184668.9104082501,0 | 0 | 0 | 0 | 0,0,0 | 9.9964261259883642,28.794128997251391,0
Pier1: 169+82.0000 70.8546° | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:10:57.361Z; User Label: Pier1: 169+82.0000 70.8546°; Origin: 5333568.7937728763,2184699.5939157899,0; Yaw: -109.145; Pitch: 0; Roll: 0; Bounding Box Low: -0.015438893809914589,-0.0036657775286939925,0; Bounding Box High: 0.015438894741237164,0.0036657750141940084,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.365Z | Line | 5333589.2276172778,2184669.374105528,0 | 0 | 0 | 0 | 0,0,0 | 9.9964261269196868,28.79412899678573,0
Pier2: 170+84.0000 70.8546° | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:10:57.375Z; User Label: Pier2: 170+84.0000 70.8546°; Origin: 5333599.8799768779,2184700.0576130678,0; Yaw: -109.145; Pitch: 0; Roll: 0; Bounding Box Low: -0.015438894741237164,-0.0036657765973714179,0; Bounding Box High: 0.015438894275575876,0.003665775945516583,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.382Z | Line | 5333603.2468857495,2184669.5832239087,0 | 0 | 0 | 0 | 0,0,0 | 9.9964261269196868,28.794128996320069,0
Abut2: 171+30.0000 70.8546° | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:10:57.394Z; User Label: Abut2: 171+30.0000 70.8546°; Origin: 5333613.8992453497,2184700.266731448,0; Yaw: -109.145; Pitch: 0; Roll: 0; Bounding Box Low: -0.015913751441985369,-0.0036657756660488433,0; Bounding Box High: 0.015913751441985369,0.0036657768768391576,0
Bearing Element: Bearing3 | [CivilDesignerProductsDynamic].[Bearing\Bearing] | Feature - Feature Definition: Bearing; Feature Name: Bearing3; [CivilDesignerProductsDynamic].[Bearing\Bearing] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.048Z; User Label: Bearing Element: Bearing3; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; Rule Property - Ahead Offset: 0 us survey foot; Model Stepped Cap: no; Model As Sloped Bearing Seats: no; Back Offset: 0 us survey foot; Active Angle: 0 deg; Has Pad or Plate: no; Has Bearing Seats: yes; Seat Min Thickness: 0 us survey foot; Bearing Orientation: Girder; Bearing Type: Cube; Seat Orientation: Pier; Grout Pad Orientation: Girder; Pad Thickness Definition: At Center; Bearing Pay Unit: 3; Pad or Plate Pay Unit: 3; Cube Width, W: 2.375 us survey foot; Cube Depth, D: 0.25 us survey foot; Cube Height: 0.25 us survey foot; Seat W2: 1.75 us survey foot; Seat D1: 1.5 us survey foot; Seat D2: 1.5 us survey foot; Seat W1: 1.75 us survey foot; Bearing Group - Name: Bearing3; Description: BU01; Material - Pad or Plate Material: Substructure Concrete - PPCB Bridges; Bearing Seat Material: Structural Steel Gr. 36; Build Order - Pad or Plate Build Order: 0; Bearing Build Order: 0; Beam Seat Build Order: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.457Z | Smart Solid | 5333549.5476606553,2184684.329154178,359.88794005588011 | 0 | 0 | 0 | -0.04350423037326534,-0.36248617280095952,-0.038095711166477864 | 0.043484318945600078,0.36247126664966345,0.038104441233826947 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing1; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.480Z | Smart Solid | 5333549.5476454152,2184684.329154178,359.79499110998222 | 0 | 0 | 0 | -0.60684532189115892,-0.65385241037543862,-0.054857356459239587 | 0.60685588885098696,0.65383750443283473,0.054853234731297107 | Solid - Surface Area: 25.6792 us survey square foot; Volume: 3.77939 ft³ (us survey); General - Bearing: Bearing1; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.359942 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.359942 us survey foot; Depth at D1W2: 0.359942 us survey foot; Depth at D2W1: 0.359942 us survey foot; Depth at D2W2: 0.359942 us survey foot; Top Elevation: 1180.61 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.499Z | Smart Solid | 5333548.6930607054,2184681.867553975,359.88403860807722 | 0 | 0 | 0 | -0.043489943885045054,-0.36247068117697445,-0.038100404145439748 | 0.043498605386537888,0.3624867582693696,0.038099748254865062 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing2; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148437 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.522Z | Smart Solid | 5333548.6930607054,2184681.867553975,359.79304038608075 | 0 | 0 | 0 | -0.6068462727715076,-0.65383691875301309,-0.05290663255780953 | 0.60685493797063839,0.65385299558687959,0.052897817850976026 | Solid - Surface Area: 25.5126 us survey square foot; Volume: 3.64483 ft³ (us survey); General - Bearing: Bearing2; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.347127 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.347127 us survey foot; Depth at D1W2: 0.347127 us survey foot; Depth at D2W1: 0.347127 us survey foot; Depth at D2W2: 0.347127 us survey foot; Top Elevation: 1180.59 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.544Z | Smart Solid | 5333550.402230124,2184686.7907239012,359.84289052578106 | 0 | 0 | 0 | -0.04348803933030565,-0.36247118316412108,-0.038085804367768483 | 0.043500509988559768,0.36248625628650188,0.038114348032536327 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing3; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.562Z | Smart Solid | 5333550.402230124,2184686.7907239012,359.7724663449327 | 0 | 0 | 0 | -0.60684437194213281,-0.65383742260124533,-0.032332591409732783 | 0.60685683880001307,0.65385249220702801,0.032338376480595343 | Solid - Surface Area: 23.7583 us survey square foot; Volume: 2.22783 ft³ (us survey); General - Bearing: Bearing3; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.212175 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.212175 us survey foot; Depth at D1W2: 0.212175 us survey foot; Depth at D2W1: 0.212175 us survey foot; Depth at D2W2: 0.212175 us survey foot; Top Elevation: 1180.46 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.579Z | Smart Solid | 5333547.8384912368,2184679.4059842518,359.83118618237233 | 0 | 0 | 0 | -0.043506132134111392,-0.36248566894688938,-0.038099379013318335 | 0.043482417090189143,0.36247177049517632,0.038100773386986475 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing4; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.600Z | Smart Solid | 5333547.8384759966,2184679.4059842518,359.76661417322833 | 0 | 0 | 0 | -0.60684722272053371,-0.65385190513294189,-0.02648041970534145 | 0.60685398802161206,0.65383800920695068,0.026472630130740527 | Solid - Surface Area: 23.2585 us survey square foot; Volume: 1.82417 ft³ (us survey); General - Bearing: Bearing4; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.17373 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.17373 us survey foot; Depth at D1W2: 0.17373 us survey foot; Depth at D2W1: 0.17373 us survey foot; Depth at D2W2: 0.17373 us survey foot; Top Elevation: 1180.42 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.618Z | Smart Solid | 5333551.2568300739,2184689.2523241048,359.79787147574291 | 0 | 0 | 0 | -0.043502330475211973,-0.36248667524955314,-0.038106897782314186 | 0.043486218844369429,0.36247076420113444,0.038093254617990624 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing5; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.640Z | Smart Solid | 5333551.2568148337,2184689.2523241048,359.74995681991362 | 0 | 0 | 0 | -0.60684342106722311,-0.65385291235558696,-0.0098230663906559643 | 0.60685779061168443,0.65383700198430572,0.0098077580468611814 | Solid - Surface Area: 21.8373 us survey square foot; Volume: 0.676257 ft³ (us survey); General - Bearing: Bearing5; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.0644055 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.0644055 us survey foot; Depth at D1W2: 0.0644055 us survey foot; Depth at D2W1: 0.0644055 us survey foot; Depth at D2W2: 0.0644055 us survey foot; Top Elevation: 1180.31 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.658Z | Smart Solid | 5333546.9838912878,2184676.9443840487,359.77833375666751 | 0 | 0 | 0 | -0.043491843782945197,-0.36247018059984226,-0.038100003144564576 | 0.043496705585350494,0.36248725885525346,0.038100149255740234 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing6; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Bearing Element: Bearing4 | [CivilDesignerProductsDynamic].[Bearing\Bearing] | Feature - Feature Definition: Bearing; Feature Name: Bearing4; [CivilDesignerProductsDynamic].[Bearing\Bearing] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.048Z; User Label: Bearing Element: Bearing4; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; Rule Property - Ahead Offset: 0 us survey foot; Model Stepped Cap: no; Model As Sloped Bearing Seats: no; Back Offset: 0 us survey foot; Active Angle: 0 deg; Has Pad or Plate: no; Has Bearing Seats: yes; Seat Min Thickness: 0 us survey foot; Bearing Orientation: Girder; Bearing Type: Cube; Seat Orientation: Pier; Grout Pad Orientation: Girder; Pad Thickness Definition: At Center; Bearing Pay Unit: 3; Pad or Plate Pay Unit: 3; Cube Width, W: 2.375 us survey foot; Cube Depth, D: 0.25 us survey foot; Cube Height: 0.25 us survey foot; Seat W2: 1.75 us survey foot; Seat D1: 1.5 us survey foot; Seat D2: 1.5 us survey foot; Seat W1: 1.75 us survey foot; Bearing Group - Name: Bearing4; Description: BU01; Material - Pad or Plate Material: Substructure Concrete - PPCB Bridges; Bearing Seat Material: Structural Steel Gr. 36; Build Order - Pad or Plate Build Order: 0; Bearing Build Order: 0; Beam Seat Build Order: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.715Z | Smart Solid | 5333607.8177952757,2184682.7494945391,359.94323088646178 | 0 | 0 | 0 | -0.043483566187866501,-0.3624772060337258,-0.038103686043314988 | 0.043504983202996443,0.36248023342341185,0.038096466356989822 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing1; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148437 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.735Z | Smart Solid | 5333607.8178105149,2184682.7494945391,359.85169926339853 | 0 | 0 | 0 | -0.60685513523712764,-0.65384344266764827,-0.053442960884368104 | 0.60684607550501812,0.65384647120386363,0.053427937019989713 | Solid - Surface Area: 25.5581 us survey square foot; Volume: 3.68157 ft³ (us survey); General - Bearing: Bearing1; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.350626 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.350626 us survey foot; Depth at D1W2: 0.350626 us survey foot; Depth at D2W1: 0.350626 us survey foot; Depth at D2W2: 0.350626 us survey foot; Top Elevation: 1180.79 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.754Z | Smart Solid | 5333608.6723952247,2184685.211079502,359.94036576073148 | 0 | 0 | 0 | -0.043497855470167712,-0.36247745841990719,-0.038088020432781755 | 0.043490693895980106,0.36247998103499413,0.038112131967523055 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing2; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.775Z | Smart Solid | 5333608.6723952247,2184685.211079502,359.85026670053338 | 0 | 0 | 0 | -0.60685418715074668,-0.65384369552172728,-0.052010398019215892 | 0.6068470235913993,0.6538462188181654,0.052011039765261557 | Solid - Surface Area: 25.4366 us survey square foot; Volume: 3.58341 ft³ (us survey); General - Bearing: Bearing2; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.341277 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.341277 us survey foot; Depth at D1W2: 0.341277 us survey foot; Depth at D2W1: 0.341277 us survey foot; Depth at D2W2: 0.341277 us survey foot; Top Elevation: 1180.78 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.797Z | Smart Solid | 5333606.9632258061,2184680.2879095757,359.89702311404619 | 0 | 0 | 0 | -0.043499756299541392,-0.3624769536431367,-0.038102254657418066 | 0.043488793067322451,0.36248048581182957,0.038097897742886744 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing3; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.819Z | Smart Solid | 5333606.9632258061,2184680.2879095757,359.82859537719077 | 0 | 0 | 0 | -0.60685608798012147,-0.65384319261025636,-0.030339074676581881 | 0.60684512276202429,0.65384672219801698,0.030325482198065856 | Solid - Surface Area: 23.5874 us survey square foot; Volume: 2.08982 ft³ (us survey); General - Bearing: Bearing3; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.19903 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.19903 us survey foot; Depth at D1W2: 0.19903 us survey foot; Depth at D2W1: 0.19903 us survey foot; Depth at D2W2: 0.19903 us survey foot; Top Elevation: 1180.64 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.843Z | Smart Solid | 5333609.5269646933,2184687.6726644654,359.88845821691643 | 0 | 0 | 0 | -0.043481668152534916,-0.36247771080621793,-0.038086778698869617 | 0.043506881190329749,0.3624797286465764,0.038113373701435194 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing4; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148437 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.861Z | Smart Solid | 5333609.5269799335,2184687.6726644654,359.82431292862583 | 0 | 0 | 0 | -0.60685323533363644,-0.65384394744448371,-0.026056626111664795 | 0.60684797447174799,0.65384596689540897,0.02605850959179179 | Solid - Surface Area: 23.2228 us survey square foot; Volume: 1.7953 ft³ (us survey); General - Bearing: Bearing4; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.170981 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.170981 us survey foot; Depth at D1W2: 0.170981 us survey foot; Depth at D2W1: 0.170981 us survey foot; Depth at D2W2: 0.170981 us survey foot; Top Elevation: 1180.61 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.879Z | Smart Solid | 5333606.1086258572,2184677.8263246124,359.85069342138684 | 0 | 0 | 0 | -0.043485467948637127,-0.362476706374951,-0.038091149847958528 | 0.043503081395659428,0.36248073307797313,0.038109002552346283 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing5; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.901Z | Smart Solid | 5333606.1086410973,2184677.8263246124,359.80543053086103 | 0 | 0 | 0 | -0.60685703886590914,-0.65384294301308699,-0.0071742283468945386 | 0.60684417281299829,0.65384697132680569,0.0071717406778475379 | Solid - Surface Area: 21.6119 us survey square foot; Volume: 0.494201 ft³ (us survey); General - Bearing: Bearing5; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.0470667 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.0470667 us survey foot; Depth at D1W2: 0.0470667 us survey foot; Depth at D2W1: 0.0470667 us survey foot; Depth at D2W2: 0.0470667 us survey foot; Top Elevation: 1180.49 us survey foot; Pad or Plate Pay Unit: 0; D1: 1.5 us survey foot; W1: 1.75 us survey foot; D2: 1.5 us survey foot; W2: 1.75 us survey foot
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:57.919Z | Smart Solid | 5333610.3815646432,2184690.1342494283,359.83645923291846 | 0 | 0 | 0 | -0.043495953709469237,-0.36247796086850115,-0.038102930404364466 | 0.043492595657394606,0.36247947858646512,0.038097221995940345 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing6; Solid - Surface Area: 2.5 us survey square foot; Volume: 0.148438 ft³ (us survey)
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.041Z | Line String | 5333549.9245849261,2184684.0206336533,0 | 0 | 0 | 0 | -2.6580260815098882,-8.1388381328433752,0 | 60.174312909133732,7.1762136006727815,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.089Z | Line String | 5333547.0365001233,2184675.9290622347,0 | 0 | 0 | 0 | -0.006440240889787674,0,0 | 58.624618776142597,1.3062268015928566,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.131Z | Line String | 5333551.7107780203,2184689.8433537395,0 | 0 | 0 | 0 | -0.006440240889787674,0,0 | 58.624618778005242,1.3062268011271954,0
Bearing1 | [BisCore].[TextAnnotation3d] | [BisCore].[TextAnnotation3d] - In Spatial Index: yes; Last Modified: 2025-09-30T17:10:58.524Z; User Label: Bearing1; Origin: 5333558.6407764573,2184668.7370448834,0; Yaw: 70.8546; Pitch: 0; Roll: 0; Bounding Box Low: -0.007112633902579546,-0.0024384042714145964,0; Bounding Box High: 0.007112633902579546,0.0024384054822049108,0
Bearing Element: Bearing1 | [CivilDesignerProductsDynamic].[Bearing\Bearing] | Feature - Feature Definition: Bearing; Feature Name: Bearing1; [CivilDesignerProductsDynamic].[Bearing\Bearing] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.048Z; User Label: Bearing Element: Bearing1; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; Rule Property - Ahead Offset: 0.75 us survey foot; Model Stepped Cap: yes; Model As Sloped Bearing Seats: no; Back Offset: -0.75 us survey foot; Active Angle: 0 deg; Has Pad or Plate: no; Has Bearing Seats: yes; Seat Min Thickness: 0 us survey foot; Bearing Orientation: Girder; Bearing Type: Cube; Seat Orientation: Pier; Grout Pad Orientation: Pier; Pad Thickness Definition: At Center; Bearing Pay Unit: 3; Pad or Plate Pay Unit: 3; Cube Width, W: 2.375 us survey foot; Cube Depth, D: 0.75 us survey foot; Cube Height: 0.0833333 us survey foot; Bearing Group - Name: Bearing1; Description: BU01; Material - Pad or Plate Material: Neoprene Bearing Pads; Bearing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Bearing Seat Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Build Order - Pad or Plate Build Order: 0; Bearing Build Order: 0; Beam Seat Build Order: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.580Z | Smart Solid | 5333563.3236728469,2184684.5346355094,359.9450139700279 | 0 | 0 | 0 | -0.11968409458000062,-0.36361399133953087,-0.012690468117000642 | 0.1196878076903954,0.36361647397279739,0.012709582683100962 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing1; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.606Z | Smart Solid | 5333563.2516941829,2184684.559629159,359.87887223774447 | 0 | 0 | 0 | -0.71523964181646704,-1.3307581118996441,-0.053455535544771268 | 0.71522974967956543,1.3307555222302676,0.053451264166426427 | Solid - Surface Area: 41.5955 us survey square foot; Volume: 5.99694 ft³ (us survey); General - Bearing: Bearing1; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.350743 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.350743 us survey foot; Depth at D1W2: 0.350743 us survey foot; Depth at D2W1: 0.350743 us survey foot; Depth at D2W2: 0.350743 us survey foot; Top Elevation: 1180.88 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.630Z | Smart Solid | 5333563.8101650998,2184684.5419050036,359.94653797307592 | 0 | 0 | 0 | -0.11968741753860787,-0.36362677655748243,-0.012698002582226586 | 0.11968448480339813,0.36360368877649307,0.012702048217875017 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing2; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.653Z | Smart Solid | 5333563.8821437638,2184684.5168961138,359.87963423926846 | 0 | 0 | 0 | -0.71522935815803712,-1.3307505868186804,-0.054217537068735708 | 0.71524003427475691,1.3307630482479931,0.054205731225181353 | Solid - Surface Area: 41.7005 us survey square foot; Volume: 6.082 ft³ (us survey); General - Bearing: Bearing2; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.355719 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.355719 us survey foot; Depth at D1W2: 0.355719 us survey foot; Depth at D2W1: 0.355719 us survey foot; Depth at D2W2: 0.355719 us survey foot; Top Elevation: 1180.88 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.672Z | Smart Solid | 5333562.4690881381,2184682.073050546,359.94216408432817 | 0 | 0 | 0 | -0.11968504639189484,-0.36361374173083216,-0.012701480825683398 | 0.11968685583136736,0.36361672356724739,0.012698569974418206 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing3; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148437 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.694Z | Smart Solid | 5333562.3970942339,2184682.0980441961,359.87743967487933 | 0 | 0 | 0 | -0.71522535160288214,-1.3307578613765911,-0.05202297267961653 | 0.71524403989315033,1.3307557732217015,0.052022928623159714 | Solid - Surface Area: 41.3975 us survey square foot; Volume: 5.83645 ft³ (us survey); General - Bearing: Bearing3; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.341357 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.341357 us survey foot; Depth at D1W2: 0.341357 us survey foot; Depth at D2W1: 0.341357 us survey foot; Depth at D2W2: 0.341357 us survey foot; Top Elevation: 1180.87 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.715Z | Smart Solid | 5333562.955580391,2184682.0803048005,359.94373380746759 | 0 | 0 | 0 | -0.11968836748753336,-0.36361128587552449,-0.012693427768056431 | 0.11968353487572889,0.36361917946487665,0.012706623032045172 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing4; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.738Z | Smart Solid | 5333563.027559055,2184682.0553263905,359.87823215646432 | 0 | 0 | 0 | -0.71523031090103095,-1.3307655764527992,-0.052815454264630635 | 0.71523908153176308,1.330748058613874,0.052808223235103924 | Solid - Surface Area: 41.5067 us survey square foot; Volume: 5.92496 ft³ (us survey); General - Bearing: Bearing4; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.346534 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.346534 us survey foot; Depth at D1W2: 0.346534 us survey foot; Depth at D2W1: 0.346534 us survey foot; Depth at D2W2: 0.346534 us survey foot; Top Elevation: 1180.87 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.756Z | Smart Solid | 5333564.1782575566,2184686.9962204723,359.89883667767333 | 0 | 0 | 0 | -0.11968314556229709,-0.36361424419360988,-0.012708234023137088 | 0.11968875670809893,0.36361622111871839,0.012691816776964515 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing5; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.781Z | Smart Solid | 5333564.1062788926,2184687.0212141224,359.85578359156716 | 0 | 0 | 0 | -0.71523869186744093,-1.3307583638224005,-0.030366889367434403 | 0.71523069962859154,1.3307552703075112,0.030344852083032947 | Solid - Surface Area: 38.3979 us survey square foot; Volume: 3.40563 ft³ (us survey); General - Bearing: Bearing5; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.199185 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.199185 us survey foot; Depth at D1W2: 0.199185 us survey foot; Depth at D2W1: 0.199185 us survey foot; Depth at D2W2: 0.199185 us survey foot; Top Elevation: 1180.73 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.801Z | Smart Solid | 5333564.6647498095,2184687.0034747268,359.90028448056893 | 0 | 0 | 0 | -0.11968646572688554,-0.36361178832088947,-0.01270090171101429 | 0.1196854366259095,0.36361867701634765,0.012699149089087314 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing6; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.833Z | Smart Solid | 5333564.7367437137,2184686.9784963168,359.85649987299973 | 0 | 0 | 0 | -0.71524364837162202,-1.3307660774989056,-0.031083170799941919 | 0.71522574406117201,1.3307475566310063,0.031083705858293342 | Solid - Surface Area: 38.4987 us survey square foot; Volume: 3.48725 ft³ (us survey); General - Bearing: Bearing6; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.203959 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.203959 us survey foot; Depth at D1W2: 0.203959 us survey foot; Depth at D2W1: 0.203959 us survey foot; Depth at D2W2: 0.203959 us survey foot; Top Elevation: 1180.73 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.853Z | Smart Solid | 5333562.1009956822,2184679.6187350773,359.89188722377446 | 0 | 0 | 0 | -0.11968931743655947,-0.36362627597802422,-0.012702416578122488 | 0.11968258492670278,0.36360418936237693,0.012697634221979115 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing7; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.874Z | Smart Solid | 5333562.1729743453,2184679.5937261875,359.85230886461773 | 0 | 0 | 0 | -0.71523125898197293,-1.3307500852960348,-0.02689216241805642 | 0.71523813251405954,1.3307635488338769,0.026875942578612921 | Solid - Surface Area: 37.9173 us survey square foot; Volume: 3.01612 ft³ (us survey); General - Bearing: Bearing7; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.176404 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.176404 us survey foot; Depth at D1W2: 0.176404 us survey foot; Depth at D2W1: 0.176404 us survey foot; Depth at D2W2: 0.176404 us survey foot; Top Elevation: 1180.7 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.895Z | Smart Solid | 5333561.6145034283,2184679.6114655826,359.89024130048261 | 0 | 0 | 0 | -0.11968599540982147,-0.36361349072515003,-0.012695550616968199 | 0.11968590676630704,0.36361697455868125,0.012704500183133405 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing8; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.916Z | Smart Solid | 5333561.5425247652,2184679.6364592328,359.85148590297177 | 0 | 0 | 0 | -0.71524154357716441,-1.3307576099167764,-0.026069200772092418 | 0.71522784791886806,1.330756024681516,0.026059846893758731 | Solid - Surface Area: 37.8039 us survey square foot; Volume: 2.92418 ft³ (us survey); General - Bearing: Bearing8; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.171027 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.171027 us survey foot; Depth at D1W2: 0.171027 us survey foot; Depth at D2W1: 0.171027 us survey foot; Depth at D2W2: 0.171027 us survey foot; Top Elevation: 1180.7 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.931Z | Smart Solid | 5333565.0328422654,2184689.4578054356,359.85252222504442 | 0 | 0 | 0 | -0.11968219095665467,-0.36361449518525935,-0.012701038024829636 | 0.11968971131445505,0.36361597012728453,0.012699012775271967 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing9; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.952Z | Smart Solid | 5333564.892207264,2184689.2850292102,359.83261874523748 | 0 | 0 | 0 | -0.64658140361189842,-1.1329887394624576,-0.0072020430377914054 | 0.64656614325940609,1.1329772409401835,0.0072024417819420705 | Solid - Surface Area: 29.568 us survey square foot; Volume: 0.67818 ft³ (us survey); General - Bearing: Bearing9; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.0472587 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.0472587 us survey foot; Depth at D1W2: 0.0472587 us survey foot; Depth at D2W1: 0.0472587 us survey foot; Depth at D2W2: 0.0472587 us survey foot; Top Elevation: 1180.57 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.971Z | Smart Solid | 5333565.5193345184,2184689.4650596902,359.85390906781811 | 0 | 0 | 0 | -0.1196855157779631,-0.36361203977136425,-0.012694102751936776 | 0.11968638655293184,0.3636184255592525,0.012705948048164828 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing10; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:58.992Z | Smart Solid | 5333565.4953771904,2184689.1636880874,359.83331978663955 | 0 | 0 | 0 | -0.61929146642252819,-1.0543731365125255,-0.0079030844398238209 | 0.61927994899451733,1.0543894416044279,0.0078951784265655078 | Solid - Surface Area: 27.4115 us survey square foot; Volume: 0.687206 ft³ (us survey); General - Bearing: Bearing10; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.0518315 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.0518315 us survey foot; Depth at D1W2: 0.0518315 us survey foot; Depth at D2W1: 0.0518315 us survey foot; Depth at D2W2: 0.0518315 us survey foot; Top Elevation: 1180.58 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:59.012Z | Smart Solid | 5333561.2464109724,2184677.1571348743,359.83991871983744 | 0 | 0 | 0 | -0.11969026924838555,-0.36361078341711406,-0.012701708968677672 | 0.11968163308218764,0.36361968191340566,0.012698341831423932 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing11; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:59.037Z | Smart Solid | 5333561.3870612141,2184677.3299263399,359.82632461264922 | 0 | 0 | 0 | -0.6465819437789917,-1.1329872940416634,-0.00090791044951327887 | 0.64656560309231281,1.1329786854242161,0.00089239821943465358 | Solid - Surface Area: 28.8091 us survey square foot; Volume: 0.0847607 ft³ (us survey); General - Bearing: Bearing11; Min. Thickness: 0 us survey foot; Orientation: Pier; Thickness at Center: 0.00590651 us survey foot; Thickness Definition: At Center; Depth at D1W1: 0.00590651 us survey foot; Depth at D1W2: 0.00590651 us survey foot; Depth at D2W1: 0.00590651 us survey foot; Depth at D2W2: 0.00590651 us survey foot; Top Elevation: 1180.53 us survey foot; Pad or Plate Pay Unit: 0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:59.057Z | Smart Solid | 5333560.7599187195,2184677.1498806197,359.83821183642368 | 0 | 0 | 0 | -0.11968694535816826,-0.36361323884578611,-0.012695134224032067 | 0.11968495696150253,0.36361722648143768,0.012704916576069536 | Feature - Feature Definition: No Feature Definition; Feature Name: Bearing12; Solid - Surface Area: 4.08333 us survey square foot; Volume: 0.148438 ft³ (us survey)
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:59.325Z | Smart Solid | 5333558.1146456692,2184689.3546151891,360.30774193548388 | 0 | 0 | 0 | -7.0674416956641331,-0.53708257386920111,-0.47220457598732246 | 7.0674395368850504,0.537059888839994,0.47218403043342277 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.582 us survey square foot; Volume: 203.108 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-L; Type: Custom; Type Text: Custom; Span Name: Abut1 - Pier1; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:01.457Z | Smart Solid | 5333558.1140817879,2184689.354599949,360.79391414782827 | 0 | 0 | 0 | -7.0668778130784631,-0.53706733323944733,-0.043977021285877028 | 7.0680670494215025,0.53827907190719193,0.045170498249184121 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.247 us survey square foot; Volume: 16.9564 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-L; Type: Haunch; Type Text: Haunch; Span Name: Abut1 - Pier1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:01.686Z | Smart Solid | 5333557.26010668,2184686.8930149861,360.35340106680212 | 0 | 0 | 0 | -7.0674883680769867,-0.53706708423264826,-0.47284188719350795 | 7.067475202536162,0.53707551193164482,0.47284536762705864 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.582 us survey square foot; Volume: 203.108 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-2; Type: Custom; Type Text: Custom; Span Name: Abut1 - Pier1; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:03.613Z | Smart Solid | 5333557.2594818389,2184686.8930149861,360.83958851917703 | 0 | 0 | 0 | -7.0668635238017394,-0.53706708411337811,-0.044629754920890718 | 7.0680813392544302,0.53827932126745148,0.045821403004333711 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.195 us survey square foot; Volume: 16.883 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-2; Type: Haunch; Type Text: Haunch; Span Name: Abut1 - Pier1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:03.813Z | Smart Solid | 5333556.4055524506,2184684.4314452629,360.39901447802896 | 0 | 0 | 0 | -7.0675197957718972,-0.5370820736223918,-0.47343237001330551 | 7.0675188505310107,0.5370606454510457,0.47343906880480457 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.582 us survey square foot; Volume: 203.108 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-3; Type: Custom; Type Text: Custom; Span Name: Abut1 - Pier1; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:05.556Z | Smart Solid | 5333556.4048971292,2184684.4314300227,360.88514097028195 | 0 | 0 | 0 | -7.0668644747424159,-0.5370668324275315,-0.045159450730352546 | 7.0680803889061181,0.53827957412424998,0.046377414012417406 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.12 us survey square foot; Volume: 16.7887 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-3; Type: Haunch; Type Text: Haunch; Span Name: Abut1 - Pier1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:05.757Z | Smart Solid | 5333555.5509982221,2184681.9698450598,360.3956311912624 | 0 | 0 | 0 | -7.0675512298913761,-0.53706658047721734,-0.47397031565689929 | 7.067555336375575,0.53707624540783172,0.47397236729708658 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.582 us survey square foot; Volume: 203.108 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-4; Type: Custom; Type Text: Custom; Span Name: Abut1 - Pier1; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:07.362Z | Smart Solid | 5333555.5503124204,2184681.9698450598,360.88175768351533 | 0 | 0 | 0 | -7.0668654252037326,-0.53706658073896552,-0.045697558572623996 | 7.0680794367542656,0.53827982417349185,0.046917801679759605 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.057 us survey square foot; Volume: 16.6993 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-4; Type: Haunch; Type Text: Haunch; Span Name: Abut1 - Pier1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:07.584Z | Smart Solid | 5333554.6964439927,2184679.5082753366,360.34325120650237 | 0 | 0 | 0 | -7.0675826551091276,-0.53708156868467594,-0.47445521594157147 | 7.0675846334712205,0.53706135482366346,0.47444525755733868 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.583 us survey square foot; Volume: 203.108 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-5; Type: Custom; Type Text: Custom; Span Name: Abut1 - Pier1; Template: IA-BTB; Is Dual Template: no
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:09.025Z | Smart Solid | 5333554.6957277115,2184679.5082600964,360.82943865887728 | 0 | 0 | 0 | -7.0668663749624798,-0.53706632834510881,-0.046243568402142908 | 7.0680784847674385,0.53828007609895934,0.047442565997417668 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 275.008 us survey square foot; Volume: 16.6178 ft³ (us survey); Beam Segment Properties - Beam Name: Beam-5; Type: Haunch; Type Text: Haunch; Span Name: Abut1 - Pier1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:09.231Z | Smart Solid | 5333553.8418897633,2184677.0466751331,360.29081026162049 | 0 | 0 | 0 | -7.0676140852125169,-0.53706608029486091,-0.47487920332149614 | 7.0676067445914619,0.53707693274199197,0.47486576303620909 | Feature - Feature Definition: No Feature Definition; Solid - Surface Area: 651.583 us survey square foot; Volume: 203.108 ft³ (us survey); Beam Segment Properties - Length: 46.3333 us survey foot; Beam Name: Beam-R; Type: Custom; Type Text: Custom; Span Name: Abut1 - Pier1; Template: IA-BTB; Is Dual Template: no
