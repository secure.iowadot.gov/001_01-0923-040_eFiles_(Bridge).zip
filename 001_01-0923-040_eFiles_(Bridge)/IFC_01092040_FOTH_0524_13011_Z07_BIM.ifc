Properties of the parts of a building model (IFC4X3_ADD2), part 27 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.088Z | Extended Element | 5333547.8346320996,2184678.2331927302,358.80032323868403 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.116Z | Extended Element | 5333546.9948494295,2184678.1376526034,358.80032323885376 | -67.7255 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.142Z | Extended Element | 5333547.7147023678,2184677.8877420495,358.80032323890117 | -67.7255 | -4.28426e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.171Z | Extended Element | 5333546.874919693,2184677.7922019199,358.80032323953884 | -67.7255 | 2.36989e-08 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.199Z | Extended Element | 5333547.5947726341,2184677.5422913656,358.80032323844659 | -67.7255 | 9.70732e-09 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.225Z | Extended Element | 5333546.7499641189,2184677.4322745902,358.74793563365779 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.253Z | Extended Element | 5333546.625008544,2184677.0723472615,358.74793563268918 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.283Z | Extended Element | 5333546.500052969,2184676.7124199262,358.74793563378387 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.308Z | Extended Element | 5333547.2031355994,2184676.4142034715,358.7479356332355 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.335Z | Extended Element | 5333546.4042536896,2184676.4364756392,358.74793563421201 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.350Z | Extended Element | 5333546.3007087419,2184675.867282019,358.67173548116017 | -89.1454 | 90 | 0 | -5.6177285046032921e-14,-5.5132454157558186e-10,-2.4438151502437222e-10 | 1.0667999999999438,0.97308415460065589,0.48259999975562096
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.375Z | Extended Element | 5333547.1929469295,2184676.1854256047,358.74793563351136 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.404Z | Extended Element | 5333546.3747003144,2184676.2287890231,358.74793563377256 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.433Z | Extended Element | 5333546.3764997935,2184676.1081522023,358.74793563377256 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.461Z | Extended Element | 5333547.1963564679,2184675.9568505748,358.74793563377267 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.490Z | Extended Element | 5333546.3782992717,2184675.9875153811,358.74793563377256 | -67.7255 | 0 | 90 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.503Z | Extended Element | 5333551.9472049167,2184689.8468804671,359.73853540994162 | -109.145 | 0 | 90 | 1.0049250320776082e-10,-1.7256869089266047e-07,-2.2156719440298014 | 7.468779500042432,1.3598278392923784,3.1300730343282579
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.517Z | Extended Element | 5333548.7430212405,2184683.405504311,361.09811901284399 | -109.145 | 0 | -90 | 4.9803716706264822e-10,-4.8849813083506888e-14,-2.215672257296732 | 7.4687798586637157,1.3595835316839124,3.1300734187589234
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.544Z | Extended Element | 5333547.5901867123,2184677.6463302821,360.07327804198866 | 160.901 | 0.0459215 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.573Z | Extended Element | 5333548.4447723711,2184680.1079149963,360.12613108948153 | 160.901 | 0.0459217 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.601Z | Extended Element | 5333549.2993580289,2184682.5694997073,360.17898248635936 | 160.901 | 0.0459217 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.630Z | Extended Element | 5333550.1539436914,2184685.0310844188,360.18288862427841 | 160.901 | 0.0459215 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.656Z | Extended Element | 5333551.0085293502,2184687.4926691316,360.13784899645066 | 160.901 | 0.0459217 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.683Z | Extended Element | 5333551.8631150108,2184689.9542538426,360.09280884830468 | 160.901 | 0.045922 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.693Z | Complex Chain | 5333551.0551548162,2184690.2574836724,360.49418705805675 | 0 | 0 | 0 | 0,-0.82010826375335455,-5.6843418860808015e-14 | 0.78569921106100082,0.011625579558312893,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.703Z | Complex Chain | 5333551.0551548162,2184690.2574836728,360.18938644845554 | 0 | 0 | 0 | 0,-0.82010826375335455,-5.6843418860808015e-14 | 0.78569921106100082,0.011625579558312893,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.716Z | Extended Element | 5333550.9670300987,2184690.3149142787,360.98350858951892 | -89.1455 | -90 | -0.0000639788 | -1.0673684158746255e-12,-0.0071971004049810605,-0.014511776558646522 | 1.2449730431285042,0.98028125384465348,0.49711177779765914
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.744Z | Extended Element | 5333551.0551548172,2184690.2574836719,360.49418705805675 | -89.1454 | -90 | 0 | -0.012497246598317946,-1.5540934307419288e-10,-0.012497246836736512 | 0.012497246598317946,0.79196130484472338,0.83233821730706048
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.774Z | Extended Element | 5333551.0551548172,2184690.2574836724,360.18938644845554 | -89.1454 | -90 | 0 | -0.012497246598317946,-1.5540934307419288e-10,-0.012497246836736512 | 0.012497246598317946,0.79196130484472338,0.83233821730706048
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.785Z | Extended Element | 5333546.3007077686,2184675.8672821061,359.73853548114135 | -89.1452 | 90 | -0.000173103 | -3.4550140526334872e-13,-0.0071970981537332057,-0.014511777815463311 | 1.2234954438994712,0.98028123623102237,0.49711167502552578
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.793Z | Complex Chain | 5333546.3870793683,2184675.927314518,360.49418912606745 | 0 | 0 | 0 | 0,0,-1.1368683772161603e-13 | 0.91467182524502277,0.84335942286998034,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.801Z | Complex Chain | 5333546.3870793683,2184675.927314518,360.18938851646624 | 0 | 0 | 0 | 0,0,-1.1368683772161603e-13 | 0.91467182524502277,0.84335942286998034,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.830Z | Extended Element | 5333546.3870793693,2184675.927314518,360.18938851646624 | -89.1454 | 90 | 0 | -0.012497246565172107,-1.8597985714131669e-11,-0.012497246803533842 | 0.01249724656505842,0.93460746318719079,0.83233821729842772
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.858Z | Extended Element | 5333546.3870793693,2184675.927314518,360.49418912606745 | -89.1454 | 90 | 0 | -0.012497246565172107,-1.8597985714131669e-11,-0.012497246803533842 | 0.01249724656505842,0.93460746318719079,0.83233821729842772
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.869Z | Circle | 5333548.3628349295,2184683.2027973547,360.68819775108136 | 0 | 0 | 0 | -0.014080788884244032,-0.0008387187055242701,-0.014905205780214533 | 0.0024158805049277025,0.0048884119397891203,0.0025573291550153275
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.878Z | Line | 5333548.3570024753,2184683.2048222013,360.68202381276876 | 0 | 0 | 0 | -0.0058324523270130157,0,0 | 0,0.002024846151471138,0.0061739384020143007
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.889Z | Complex Chain | 5333545.9819544507,2184675.9133297522,360.55088933517703 | 0 | 0 | 0 | -0.0064402399584650993,0,-5.6843418860808015e-14 | 2.458919620141387,7.5330797429196537,0.13411226822444178
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.900Z | Circle | 5333548.3548628539,2184683.2240499649,360.41948080638451 | 0 | 0 | 0 | -0.005055530799600744,-0.0039720084304072176,-0.016781881535043727 | 0.011441138444516325,0.0017551226327277934,0.00068065340018613404
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.908Z | Line | 5333548.3580556577,2184683.222941522,360.41143019215963 | 0 | 0 | 0 | -0.0076053282245993614,0,-0.0033797404643109985 | 0,0.0026403334923088551,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.918Z | Complex Chain | 5333545.9819544153,2184675.9133321084,360.28029571456796 | 0 | 0 | 0 | -0.0064402399584650993,0,-5.6843418860808015e-14 | 2.458919620141387,7.5330797433853149,0.13411226822449862
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.927Z | Complex Chain | 5333550.6497945031,2184690.2593755149,360.56674030132052 | 0 | 0 | 0 | -2.4590113051235676,-7.5333428215235472,0 | 0.0064402241259813309,0,0.11734823469646471
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.937Z | Line | 5333548.3570024753,2184683.2048222013,360.68202381276876 | 0 | 0 | 0 | 0,0,-0.27059362060907688 | 9.3132257461547852e-10,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.947Z | Complex Chain | 5333550.6497945031,2184690.2593755149,360.2961466807115 | 0 | 0 | 0 | -2.4590113051235676,-7.5333428215235472,0 | 0.0064402241259813309,0,0.11734823469646471
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.956Z | Line | 5333546.3950997433,2184676.3513436881,360.53066212581336 | 0 | 0 | 0 | 0,0,-0.32385064770130612 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.966Z | Line | 5333546.3950997433,2184676.3513436881,360.20681147811206 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,-0.32543815087620942 | 9.3132257461547852e-10,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.976Z | Complex Chain | 5333546.4046813333,2184675.9196377131,360.53066212581342 | 0 | 0 | 0 | -0.0064402399584650993,0,-5.6843418860808015e-14 | 2.458919620141387,7.5330797433853149,0.13411226822449862
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.986Z | Complex Chain | 5333546.4046813333,2184675.9196377131,360.20681147811212 | 0 | 0 | 0 | -0.0064402399584650993,0,-5.6843418860808015e-14 | 2.458919620141387,7.5330797433853149,0.13411226822449862
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:20.995Z | Complex Chain | 5333546.4046813343,2184675.9196377127,359.88137332723591 | 0 | 0 | 0 | -0.0064402399584650993,0,-5.6843418860808015e-14 | 2.458919620141387,7.5330797433853149,0.13411226822444178
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.006Z | Complex Chain | 5333551.0725183887,2184690.2656810749,360.54742615934134 | 0 | 0 | 0 | -2.4590113051235676,-7.5333428215235472,0 | 0.0064402241259813309,0,0.11734823469646471
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.017Z | Complex Chain | 5333551.0725183887,2184690.2656810749,360.22357551164004 | 0 | 0 | 0 | -2.4590113051235676,-7.5333428215235472,0 | 0.0064402241259813309,0,0.11734823469646471
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.026Z | Complex Chain | 5333551.0725183887,2184690.2656810749,359.89813736076371 | 0 | 0 | 0 | -2.4590113051235676,-7.5333428215235472,0 | 0.0064402241259813309,0,0.11734823469646471
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.054Z | Extended Element | 5333551.0725183887,2184690.2656810754,360.54742615926273 | -179.145 | -87.2473 | -0.00000267306 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.082Z | Extended Element | 5333551.0725183887,2184690.2656810754,360.22357551163435 | -179.145 | -87.2473 | -0.00000267306 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.110Z | Extended Element | 5333551.0725183869,2184690.2656810754,359.89813736078145 | -179.145 | -87.2473 | -0.00000267306 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.138Z | Extended Element | 5333550.649794504,2184690.2593755149,360.56674030131103 | -179.145 | -87.2473 | -0.00000239693 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.167Z | Extended Element | 5333550.6497945031,2184690.2593755149,360.29614668068291 | -179.145 | -87.2473 | -0.00000239693 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.197Z | Extended Element | 5333545.9819544517,2184675.9133297522,360.55088933515549 | 0.854587 | -86.8548 | -0.00000209132 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.224Z | Extended Element | 5333545.9819544163,2184675.9133321084,360.28029571461678 | 0.854587 | -86.8548 | -0.00000217987 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.253Z | Extended Element | 5333546.4046813343,2184675.9196377136,360.53066212582593 | 0.854587 | -86.8548 | -0.00000216903 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.277Z | Extended Element | 5333546.4046813333,2184675.9196377131,360.20681147813798 | 0.854587 | -86.8548 | -0.00000216931 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.304Z | Extended Element | 5333546.4046813352,2184675.9196377122,359.88137332719566 | 0.854587 | -86.8548 | -0.00000237005 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.328Z | Extended Element | 5333550.8280897895,2184686.9234411293,360.58560048731925 | -19.1454 | 90.0048 | 2.32682e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.355Z | Extended Element | 5333550.8280897886,2184686.9234411283,360.25857483326786 | -19.1454 | 90.0048 | 9.31575e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.387Z | Extended Element | 5333550.9322194355,2184687.2233805726,359.93154917921657 | -19.1454 | 90.0048 | -2.33105e-15 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.418Z | Extended Element | 5333549.9735041289,2184684.461856416,360.63065051144196 | -19.1454 | 90.0048 | 0 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.445Z | Extended Element | 5333549.9735041298,2184684.461856415,360.30362485739067 | -19.1454 | 90.0048 | -6.98594e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.473Z | Extended Element | 5333550.0776337767,2184684.7617958584,359.97659920333928 | -19.1454 | 90.0048 | -1.16538e-14 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.502Z | Extended Element | 5333549.1189184925,2184682.0002716845,360.66626423891518 | -19.1454 | 90.0048 | -6.97891e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.524Z | Extended Element | 5333549.1189184925,2184682.0002716836,360.33923858486389 | -19.1454 | 90.0048 | -9.31366e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.552Z | Extended Element | 5333549.2230481366,2184682.3002111292,360.01221293081244 | -19.1454 | 90.0048 | 6.99159e-15 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.581Z | Extended Element | 5333548.2643327564,2184679.538687042,360.62146138746067 | -19.1454 | 90.0048 | -6.97978e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.607Z | Extended Element | 5333548.2643327555,2184679.5386870424,360.29443573340927 | -19.1454 | 90.0048 | -6.98612e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.637Z | Extended Element | 5333548.3684624024,2184679.8386264867,359.96741007935805 | -19.1454 | 90.0048 | 0 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.664Z | Extended Element | 5333547.4097470194,2184677.0771024018,360.56856879148864 | -19.1454 | 90.0048 | 9.30774e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.691Z | Extended Element | 5333547.4097470194,2184677.0771024008,360.24154313743759 | -19.1454 | 90.0048 | 2.32905e-15 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.714Z | Extended Element | 5333547.5138766654,2184677.3770418456,359.91451748338631 | -19.1454 | 90.0048 | -9.32465e-15 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.740Z | Extended Element | 5333554.6768975519,2184689.8219380826,360.87729244929733 | -89.1454 | 9.23138e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.770Z | Extended Element | 5333554.5570168514,2184689.476625544,360.88313259437047 | -89.1454 | 9.708e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.800Z | Extended Element | 5333554.4320612736,2184689.1166982101,360.88971971006981 | -89.1454 | 0.00000264849 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.829Z | Extended Element | 5333554.3121315436,2184688.7712475332,360.89604187128253 | -89.1454 | 8.60364e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.856Z | Extended Element | 5333554.192201809,2184688.4257968538,360.90236404036676 | -89.1454 | 9.22913e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.886Z | Extended Element | 5333554.0722720791,2184688.0803461769,360.9086862093888 | -89.1454 | 8.05372e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.912Z | Extended Element | 5333553.9523423463,2184687.7348954966,360.91500837810668 | -89.1454 | 8.60589e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.941Z | Extended Element | 5333553.8273867657,2184687.3749681665,360.92157404054109 | -89.1454 | 9.70574e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.972Z | Extended Element | 5333553.7024311898,2184687.0150408344,360.92818259707582 | -89.1454 | 9.15582e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:21.996Z | Extended Element | 5333553.5774756148,2184686.6551135005,360.93476970641126 | -89.1454 | 9.15582e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.021Z | Extended Element | 5333553.457545884,2184686.3096628208,360.94109187555296 | -89.1454 | 9.15582e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.049Z | Extended Element | 5333553.3376161493,2184685.9642121443,360.94741404430494 | -89.1454 | 9.7813e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.074Z | Extended Element | 5333553.2176864156,2184685.6187614631,360.95373621299751 | -89.1454 | 9.15582e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.101Z | Extended Element | 5333553.0977566857,2184685.2733107838,360.96005838230002 | -89.1454 | 8.60589e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.124Z | Extended Element | 5333552.9728011098,2184684.9133834522,360.96662404551154 | -89.1454 | 9.23138e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.149Z | Extended Element | 5333552.8478455273,2184684.553456123,360.97323260041912 | -89.1454 | 8.05372e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.180Z | Extended Element | 5333552.7228899579,2184684.1935287891,360.97981971026286 | -89.1454 | 8.60364e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.205Z | Extended Element | 5333552.6029602243,2184683.8480781103,360.98583722514758 | -89.1454 | 8.60589e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.233Z | Extended Element | 5333552.4830304915,2184683.5026274305,360.98959218883908 | -89.1454 | 8.60589e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.261Z | Extended Element | 5333552.3631007588,2184683.157176754,360.99075345794574 | -89.1454 | 8.60589e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.289Z | Extended Element | 5333550.0633337004,2184676.5328303631,360.8582806616194 | -89.1454 | 8.60589e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.319Z | Extended Element | 5333550.159132977,2184676.8087746501,360.86377035646143 | -89.1454 | 9.08026e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.344Z | Extended Element | 5333550.284088552,2184677.1687019835,360.87157108518494 | -89.1454 | 8.05597e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.373Z | Extended Element | 5333550.4090441205,2184677.5286293165,360.87934314509278 | -89.1454 | 8.6792e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.400Z | Extended Element | 5333550.5339997029,2184677.8885566434,360.88692731870577 | -89.1454 | 0.00000270371 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.431Z | Extended Element | 5333550.6539294394,2184678.2340073269,360.89446152987108 | -89.1454 | 8.68145e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.460Z | Extended Element | 5333550.7738591703,2184678.5794580071,360.90188430243484 | -89.1454 | 8.68146e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.488Z | Extended Element | 5333550.8937889021,2184678.9249086869,360.90930707532675 | -89.1454 | 8.05372e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.519Z | Extended Element | 5333551.0137186358,2184679.2703593681,360.91672984801983 | -89.1454 | 9.15582e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.547Z | Extended Element | 5333551.138674208,2184679.6302867006,360.92446368371606 | -89.1454 | 7.98041e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.574Z | Extended Element | 5333551.2636297839,2184679.9902140349,360.93223574344302 | -89.1454 | 8.05372e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.600Z | Extended Element | 5333551.3885853654,2184680.350141366,360.93993135538619 | -89.1454 | 9.15582e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.630Z | Extended Element | 5333551.5085151,2184680.6955920435,360.94735412768193 | -89.1454 | 8.60139e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.657Z | Extended Element | 5333551.6284448318,2184681.0410427195,360.95477690040912 | -89.1454 | 9.23363e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.685Z | Extended Element | 5333551.7483745646,2184681.3864933979,360.96219967301164 | -89.1454 | 9.15582e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.715Z | Extended Element | 5333551.8683042955,2184681.7319440763,360.96962244596466 | -89.1454 | 8.6792e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.744Z | Extended Element | 5333551.9932598658,2184682.0918714087,360.97735628167419 | -89.1454 | 9.15356e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.772Z | Extended Element | 5333552.1182154445,2184682.4517987408,360.98446236337378 | -89.1454 | 8.60589e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.800Z | Extended Element | 5333552.2431710232,2184682.8117260723,360.98912544421501 | -89.1454 | 9.708e-07 | -179.749 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.810Z | Line | 5333606.3118119594,2184677.8293573633,360.80481489985743 | 0 | 0 | 0 | -0.00189244095236063,-2.8221867978572845e-05,-0.91439987007026957 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.822Z | Line | 5333607.1663977122,2184680.2909420622,360.84983548282105 | 0 | 0 | 0 | -0.0019765272736549377,-2.9476825147867203e-05,-0.91439969214474104 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.832Z | Line | 5333608.0209834669,2184682.7525267606,360.89485718341302 | 0 | 0 | 0 | -0.0020532002672553062,-3.062048926949501e-05,-0.91439952315852224 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.842Z | Line | 5333608.875569162,2184685.2141114571,360.89093473416472 | 0 | 0 | 0 | -0.0021225651726126671,-3.1655654311180115e-05,-0.91439936474125716 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.853Z | Line | 5333609.7301548002,2184687.6756961541,360.83806864498786 | 0 | 0 | 0 | -0.0021845819428563118,-3.2579060643911362e-05,-0.91439921864616736 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.866Z | Line | 5333610.5847404348,2184690.137280853,360.7852025227869 | 0 | 0 | 0 | -0.0022392617538571358,-3.3394899219274521e-05,-0.91439908634288258 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.875Z | Line | 5333611.4773520352,2184690.7348616333,360.68872099590425 | 0 | 0 | 0 | 0,0,-1.7530510376673192e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.886Z | Line | 5333610.3815629277,2184690.1342501594,361.0306063439192 | 0 | 0 | 0 | -0.0026746755465865135,-3.9888545870780945e-05,-1.0921989086824055 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.894Z | Line | 5333611.1734010829,2184689.8593484242,360.70613902116395 | 0 | 0 | 0 | -4.6007335186004639e-07,-3.7252902984619141e-09,-0.38100076200061039 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.905Z | Line | 5333610.813474468,2184689.9843037575,360.70353325824715 | 0 | 0 | 0 | -1.0067597031593323e-06,-8.3819031715393066e-09,-0.83820167640243426 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.913Z | Line | 5333611.1734010102,2184689.8593484242,360.64740140369116 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057629195292975 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.925Z | Line | 5333609.5269772857,2184687.6726654577,361.07957869651489 | 0 | 0 | 0 | -0.0026093581691384315,-3.8913916796445847e-05,-1.0921990667244472 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.936Z | Line | 5333610.3188154362,2184687.3977637221,360.75511137237891 | 0 | 0 | 0 | -4.5727938413619995e-07,-3.2596290111541748e-09,-0.38100076200333888 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.945Z | Line | 5333609.9588888232,2184687.5227190549,360.75250561108629 | 0 | 0 | 0 | -1.0095536708831787e-06,-8.8475644588470459e-09,-0.83820167640243426 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.956Z | Line | 5333610.3188153664,2184687.3977637221,360.69637375490339 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057612935801444 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.970Z | Line | 5333609.4642297979,2184684.9361790279,360.80408372540609 | 0 | 0 | 0 | -4.5914202928543091e-07,-3.7252902984619141e-09,-0.38100076200151989 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.979Z | Line | 5333609.104303183,2184685.0611343603,360.80147796378918 | 0 | 0 | 0 | -1.0086223483085632e-06,-9.3132257461547852e-09,-0.8382016764034006 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.990Z | Line | 5333608.6723916437,2184685.2110807621,361.12855104964103 | 0 | 0 | 0 | -1.3150274753570557e-06,-1.1641532182693481e-08,-1.0922021844028222 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:22.998Z | Line | 5333609.4642297262,2184684.936179027,360.74534610793143 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057616187245003 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.007Z | Line | 5333608.6096440852,2184682.4745943295,360.79639493785271 | 0 | 0 | 0 | -4.5541673898696899e-07,-3.2596290111541748e-09,-0.38100076200242938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.018Z | Line | 5333608.2497176444,2184682.599550135,360.79867579685373 | 0 | 0 | 0 | -1.0095536708831787e-06,-8.8475644588470459e-09,-0.8382016764034006 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.025Z | Line | 5333608.6096440163,2184682.474594329,360.7376573203772 | 0 | 0 | 0 | -0.35992644354701042,0,0 | 0,0.1249558050185442,0.0022808590009617546
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.034Z | Line | 5333607.8178059487,2184682.7494960646,361.13161281080977 | 0 | 0 | 0 | -1.3150274753570557e-06,-1.0710209608078003e-08,-1.0922021844037317 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.045Z | Line | 5333607.7550583342,2184680.013009632,360.75354610699861 | 0 | 0 | 0 | -4.5727938413619995e-07,-3.7252902984619141e-09,-0.38100076200061039 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.054Z | Line | 5333607.3951321356,2184680.1379648242,360.75582712362745 | 0 | 0 | 0 | -1.0076910257339478e-06,-9.3132257461547852e-09,-0.83820167640425325 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.063Z | Line | 5333606.963220194,2184680.2879113671,361.0887639787839 | 0 | 0 | 0 | -1.3131648302078247e-06,-1.2107193470001221e-08,-1.0922021844037886 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.074Z | Line | 5333607.7550582653,2184680.0130096311,360.6948084895231 | 0 | 0 | 0 | -0.35992620047181845,0,0 | 0,0.12495519267395139,0.0022810166279327859
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.083Z | Line | 5333606.9004725823,2184677.5514249336,360.71069727690031 | 0 | 0 | 0 | -4.5821070671081543e-07,-4.1909515857696533e-09,-0.38100076200151989 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.092Z | Line | 5333606.5405459758,2184677.6763802674,360.71297812665671 | 0 | 0 | 0 | -1.0095536708831787e-06,-9.7788870334625244e-09,-0.83820167640152476 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.103Z | Line | 5333606.1086344449,2184677.8263266692,361.04591514801245 | 0 | 0 | 0 | -1.3150274753570557e-06,-1.1175870895385742e-08,-1.0922021844046981 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.112Z | Line | 5333606.9004725134,2184677.5514249331,360.65195965942382 | 0 | 0 | 0 | -0.3599266093224287,0,0 | 0,0.12495533376932144,0.0022808497600976807
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.120Z | Line | 5333609.1369929472,2184683.9935923391,360.76409853504833 | 0 | 0 | 0 | -2.3403593227267265,-6.7412692978978157,-0.1173453463005103 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.129Z | Line | 5333611.4773519645,2184690.7348616328,360.62998337842964 | 0 | 0 | 0 | -2.3403590172529221,-6.7412692937068641,0 | 0,0,0.13411515661869089
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.140Z | Line | 5333611.1650706409,2184689.8353532697,360.64787877754338 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057629204387922 | 0,0.12495533144101501,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.150Z | Line | 5333611.1593435071,2184689.8188565997,360.64820697299814 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057629204387922 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.158Z | Line | 5333611.040115064,2184689.47542594,360.65503940354159 | 0 | 0 | 0 | -0.35992661211639643,0,-0.0026057629195292975 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.170Z | Line | 5333611.0343879331,2184689.458929271,360.65536759881473 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057629186198028 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.179Z | Line | 5333610.9151594909,2184689.1154986075,360.66220003003218 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057629195292975 | 0,0.12495533376932144,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.191Z | Line | 5333610.9094323609,2184689.0990019385,360.66252822577314 | 0 | 0 | 0 | -0.35992661025375128,0,-0.0026057629204387922 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.202Z | Line | 5333610.4354405683,2184687.7336958968,360.68969050426347 | 0 | 0 | 0 | -0.359926613047719,0,-0.002605761291761155 | 0,0.12495533190667629,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.212Z | Line | 5333610.4297134392,2184687.7171992278,360.69001869963739 | 0 | 0 | 0 | -0.35992661211639643,0,-0.0026057612908516603 | 0,0.12495533190667629,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.223Z | Line | 5333610.7952297619,2184688.7700479301,360.66907264873265 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057629213482869 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.233Z | Line | 5333610.7895026291,2184688.7535512606,360.66940084447447 | 0 | 0 | 0 | -0.35992661118507385,0,-0.0026057629186198028 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.243Z | Line | 5333610.6753000282,2184688.4245972522,360.67594526730227 | 0 | 0 | 0 | -0.35992661118507385,0,-0.0026057629195292975 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.254Z | Line | 5333610.6695728991,2184688.4081005827,360.67627346304408 | 0 | 0 | 0 | -0.35992661211639643,0,-0.0026057629204387922 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.264Z | Line | 5333610.5553703001,2184688.0791465733,360.68281788561751 | 0 | 0 | 0 | -0.35992661491036415,0,-0.0026057629186198028 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.275Z | Line | 5333610.5496431682,2184688.0626499043,360.68314608135933 | 0 | 0 | 0 | -0.35992661211639643,0,-0.0026057629177103081 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.285Z | Line | 5333610.3104849942,2184687.3737685662,360.69685113024445 | 0 | 0 | 0 | -0.35992661211639643,0,-0.0026057612926706497 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.296Z | Line | 5333610.3047578633,2184687.3572718971,360.6971793260916 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057612926138063 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.307Z | Line | 5333610.1855294211,2184687.0138412351,360.7040117565025 | 0 | 0 | 0 | -0.359926613047719,0,-0.002605761291761155 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.318Z | Line | 5333610.1798022883,2184686.9973445656,360.7043399519427 | 0 | 0 | 0 | -0.35992661118507385,0,-0.0026057612917043116 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.327Z | Line | 5333610.0605738461,2184686.6539139068,360.71117238319016 | 0 | 0 | 0 | -0.35992661211639643,0,-0.002605761293523301 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.339Z | Line | 5333610.0548467161,2184686.6374172373,360.71150057825434 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057612907948169 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.349Z | Line | 5333609.5808549291,2184685.2721112017,360.7386628567919 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057616205434897 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.360Z | Line | 5333609.5751277991,2184685.2556145317,360.73899105210774 | 0 | 0 | 0 | -0.35992661397904158,0,-0.002605761617871849 | 0,0.12495533376932144,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.371Z | Line | 5333609.9406441143,2184686.3084632312,360.71804500139552 | 0 | 0 | 0 | -0.35992661211639643,0,-0.0026057612917043116 | 0,0.12495533190667629,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.379Z | Line | 5333609.9349169843,2184686.2919665612,360.71837319646244 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057612926138063 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.389Z | Line | 5333609.8207143862,2184685.9630125547,360.72491761966268 | 0 | 0 | 0 | -0.35992661211639643,0,-0.002605761293523301 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.397Z | Line | 5333609.8149872562,2184685.9465158852,360.72524581472777 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057612890326709 | 0,0.12495533190667629,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.409Z | Line | 5333609.7007846562,2184685.6175618782,360.73179023813509 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057612907948169 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.420Z | Line | 5333609.6950575272,2184685.6010652101,360.73211843320109 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057612926138063 | 0,0.12495533190667629,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.429Z | Line | 5333609.4558993569,2184684.912183872,360.74582348324799 | 0 | 0 | 0 | -0.35992661584168673,0,-0.0026057616159960162 | 0,0.12495533190667629,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.442Z | Line | 5333609.450172225,2184684.895687202,360.74615167866642 | 0 | 0 | 0 | -0.35992661397904158,0,-0.002605761619633995 | 0,0.12495533283799887,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.452Z | Line | 5333609.330943781,2184684.5522565423,360.75298410939519 | 0 | 0 | 0 | -0.35992661491036415,0,-0.0026057616169055109 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.462Z | Line | 5333609.32521665,2184684.5357598732,360.75331230475462 | 0 | 0 | 0 | -0.359926613047719,0,-0.002605761619633995 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.474Z | Line | 5333609.205988206,2184684.1923292121,360.76014473586218 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057616178150056 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.484Z | Line | 5333609.200261076,2184684.1758325431,360.76047293096087 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057616187245003 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.493Z | Line | 5333608.726269234,2184682.8105265037,360.7435048956923 | 0 | 0 | 0 | -0.35992644261568785,0,0 | 0,0.1249558050185442,0.002280859002780744
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.505Z | Line | 5333608.7205421021,2184682.7940298342,360.74321773768025 | 0 | 0 | 0 | -0.35992644168436527,0,0 | 0,0.12495580594986677,0.0022808590000522599
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.514Z | Line | 5333608.8461989788,2184683.1559771807,360.74951815905331 | 0 | 0 | 0 | -0.3599264407530427,0,0 | 0,0.12495580548420548,0.0022808590000522599
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.528Z | Line | 5333608.8404718451,2184683.1394805117,360.74923100104218 | 0 | 0 | 0 | -0.3599264407530427,0,0 | 0,0.12495580594986677,0.0022808590010185981
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.539Z | Line | 5333608.9661287237,2184683.5014278581,360.75553142270047 | 0 | 0 | 0 | -0.35992644168436527,0,0 | 0,0.12495580455288291,0.0022808590000522599
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.551Z | Line | 5333608.9604015918,2184683.4849311896,360.75524426468934 | 0 | 0 | 0 | -0.35992644168436527,0,0 | 0,0.12495580455288291,0.0022808590010185981
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.560Z | Line | 5333609.0860584704,2184683.8468785351,360.76154468635855 | 0 | 0 | 0 | -0.35992644354701042,0,0 | 0,0.12495580455288291,0.0022808590018712493
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.570Z | Line | 5333609.0803313376,2184683.8303818656,360.76125752834741 | 0 | 0 | 0 | -0.3599264407530427,0,0 | 0,0.1249558050185442,0.0022808590009617546
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.580Z | Line | 5333608.6013136413,2184682.4505991735,360.73723963681539 | 0 | 0 | 0 | -0.35992644168436527,0,0 | 0,0.12495580548420548,0.0022808590010185981
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.592Z | Line | 5333608.5955865132,2184682.434102504,360.73695247873525 | 0 | 0 | 0 | -0.35992644168436527,0,0 | 0,0.1249558050185442,0.0022808590001091034
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.602Z | Line | 5333608.4763580551,2184682.0906718434,360.73097437786134 | 0 | 0 | 0 | -0.35992644354701042,0,0 | 0,0.12495580455288291,0.002280859002780744
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.611Z | Line | 5333608.4706309214,2184682.0741751734,360.73068722037709 | 0 | 0 | 0 | -0.3599264407530427,0,0 | 0,0.1249558050185442,0.0022808590000522599
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.622Z | Line | 5333608.3514024625,2184681.7307445137,360.72470911880185 | 0 | 0 | 0 | -0.3599264407530427,0,0 | 0,0.12495580455288291,0.0022808590010185981
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.634Z | Line | 5333608.3456753325,2184681.7142478446,360.72442196121767 | 0 | 0 | 0 | -0.35992644354701042,0,0 | 0,0.12495580408722162,0.0022808590028375875
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.642Z | Line | 5333607.8716834821,2184680.3489418058,360.70065606454932 | 0 | 0 | 0 | -0.35992620047181845,0,0 | 0,0.12495519267395139,0.0022810166297517753
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.652Z | Line | 5333607.8659563521,2184680.3324451367,360.70036890686066 | 0 | 0 | 0 | -0.35992620047181845,0,0 | 0,0.1249551922082901,0.0022810166297517753
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.661Z | Line | 5333608.2314727185,2184681.3852938362,360.71869585524735 | 0 | 0 | 0 | -0.35992644261568785,0,0 | 0,0.1249558050185442,0.0022808590019280928
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.672Z | Line | 5333608.2257455867,2184681.3687971681,360.71840869766498 | 0 | 0 | 0 | -0.35992644261568785,0,0 | 0,0.12495580362156034,0.0022808590028375875
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.680Z | Line | 5333608.1115429718,2184681.0398431602,360.71268259206983 | 0 | 0 | 0 | -0.35992644168436527,0,0 | 0,0.1249558050185442,0.0022808590009617546
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.697Z | Line | 5333608.1058158427,2184681.0233464902,360.71239543448473 | 0 | 0 | 0 | -0.359926444478333,0,0 | 0,0.12495580594986677,0.0022808590036902388
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.707Z | Line | 5333607.991613226,2184680.6943924837,360.70666932826822 | 0 | 0 | 0 | -0.35992644168436527,0,0 | 0,0.12495580455288291,0.0022808590019280928
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.717Z | Line | 5333607.985886096,2184680.6778958142,360.70638217068586 | 0 | 0 | 0 | -0.35992644354701042,0,0 | 0,0.1249558050185442,0.0022808590028375875
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.725Z | Line | 5333607.7467278922,2184679.9890144756,360.69439080573693 | 0 | 0 | 0 | -0.35992620047181845,0,0 | 0,0.1249551922082901,0.0022810166297517753
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.735Z | Line | 5333607.7410007622,2184679.9725178066,360.69410364796016 | 0 | 0 | 0 | -0.35992620140314102,0,0 | 0,0.12495519267395139,0.0022810166270801346
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.744Z | Line | 5333607.6217723023,2184679.629087145,360.68812554668204 | 0 | 0 | 0 | -0.35992619954049587,0,0 | 0,0.12495519174262881,0.0022810166261137965
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.755Z | Line | 5333607.6160451695,2184679.6125904755,360.68783838862277 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.1249551922082901,0.0022810166288422806
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.763Z | Line | 5333607.4968167124,2184679.2691598148,360.68186028799317 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.1249551922082901,0.0022810166279327859
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.774Z | Line | 5333607.4910895815,2184679.2526631453,360.68157313070151 | 0 | 0 | 0 | -0.35992619954049587,0,0 | 0,0.1249551922082901,0.0022810166270232912
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.783Z | Line | 5333607.0170977302,2184677.8873571083,360.65780723328282 | 0 | 0 | 0 | -0.35992660652846098,0,0 | 0,0.12495533330366015,0.0022808497545838691
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.791Z | Line | 5333607.0113705974,2184677.8708604397,360.65752007601566 | 0 | 0 | 0 | -0.35992660839110613,0,0 | 0,0.12495533283799887,0.0022808497564597019
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.800Z | Line | 5333607.3768869666,2184678.9237091383,360.67584702473391 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.12495519267395139,0.0022810166270232912
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.808Z | Line | 5333607.3711598339,2184678.9072124683,360.67555986744225 | 0 | 0 | 0 | -0.35992619674652815,0,0 | 0,0.12495519313961267,0.0022810166252043018
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.816Z | Line | 5333607.256957219,2184678.5782584613,360.66983376054174 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.1249551922082901,0.0022810166261137965
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.825Z | Line | 5333607.2512300881,2184678.5617617918,360.66954660324819 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.12495519267395139,0.0022810166270801346
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.833Z | Line | 5333607.1370274751,2184678.2328077848,360.66382049706078 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.12495519267395139,0.0022810166288422806
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.842Z | Line | 5333607.1313003432,2184678.2163111153,360.66353333976912 | 0 | 0 | 0 | -0.3599261986091733,0,0 | 0,0.12495519313961267,0.0022810166261137965
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.853Z | Line | 5333606.8202926768,2184677.3204715624,360.64793945059921 | 0 | 0 | 0 | -0.35992660839110613,0,0 | 0,0.12495533330366015,0.0022808497554933638
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.861Z | Line | 5333606.8145655468,2184677.3039748939,360.64765229302958 | 0 | 0 | 0 | -0.3599266093224287,0,0 | 0,0.12495533283799887,0.0022808497582218479
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.871Z | Line | 5333611.290026213,2184690.195280598,360.64071815135162 | 0 | 0 | 0 | -0.359926613047719,0,-0.0026057629195292975 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.883Z | Line | 5333611.2842990831,2184690.1787839294,360.64104634658116 | 0 | 0 | 0 | -0.35992661397904158,0,-0.0026057629168008134 | 0,0.12495533237233758,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.892Z | Line | 5333611.385825485,2184690.4712248845,360.63522833828046 | 0 | 0 | 0 | -0.35992661211639643,0,-0.0026057629195292975 | 0,0.12495533330366015,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.902Z | Line | 5333611.380098355,2184690.454728215,360.63555653373612 | 0 | 0 | 0 | -0.35992661118507385,0,-0.0026057629213482869 | 0,0.12495533330366015,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.911Z | Complex Chain | 5333606.7648035204,2184677.3397355457,360.35142798857646 | 0 | 0 | 0 | -1.1349381553009152,-0.016929285135120153,0 | 3.105187867044612e-07,3.4472612900088989e-09,0.29686445929996808
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.923Z | Complex Chain | 5333606.759076749,2184677.3232388804,360.6480039246016 | 0 | 0 | 0 | -0.60159750282764435,-0.0089737134985625744,-0.6016654879785478 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.933Z | Complex Chain | 5333606.9616085747,2184677.9066210925,360.36129577176331 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.0936044158325071e-07,0.37226350884884596,0.29686437971798796
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.941Z | Complex Chain | 5333606.9558818024,2184677.8901244239,360.65787170773035 | 0 | 0 | 0 | -0.56838596612215042,-4.1909515857696533e-09,-0.60166551019681813 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.950Z | Complex Chain | 5333607.0758115361,2184678.2355750762,360.66388497075434 | 0 | 0 | 0 | -0.56838596519082785,-3.2596290111541748e-09,-0.60166551019892134 | 0,0.1973256841301918,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.958Z | Complex Chain | 5333607.0815383093,2184678.2520717443,360.36730903478554 | 0 | 0 | 0 | -1.0722831469029188,0,0 | 3.1029176417174398e-07,0.37226350931450725,0.29686437971889745
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:23.968Z | Complex Chain | 5333607.1957412837,2184678.5810257527,360.66989823398455 | 0 | 0 | 0 | -0.56838596519082785,-3.7252902984619141e-09,-0.60166551019784131 | 0,0.19732568506151438,0
