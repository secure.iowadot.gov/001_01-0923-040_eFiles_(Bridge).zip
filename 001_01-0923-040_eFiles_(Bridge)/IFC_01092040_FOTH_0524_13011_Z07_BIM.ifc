Properties of the parts of a building model (IFC4X3_ADD2), part 39 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.099Z | Extended Element | 5333607.4085167926,2184677.1676510535,360.65061739913409 | 90.8532 | 90.0098 | 0.00135254 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.122Z | Extended Element | 5333607.4132030113,2184676.8534873235,360.97104750618502 | 90.8532 | 90.0098 | 0.00135134 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.145Z | Extended Element | 5333607.4110957459,2184676.9947581934,360.66816006348961 | 90.8532 | 90.0098 | 0.00135248 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.169Z | Extended Element | 5333607.4082781393,2184677.1836502911,360.33018729124092 | 90.8532 | 90.0098 | 0.00135375 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.193Z | Extended Element | 5333607.4132030141,2184676.853487324,360.65061739843384 | 90.8532 | 90.0098 | 0.00135254 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.216Z | Extended Element | 5333607.4110957477,2184676.9947581929,360.33018729099393 | 90.8532 | 90.0098 | 0.00135375 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.242Z | Extended Element | 5333607.4082781402,2184677.1836502911,360.00975718395148 | 90.8532 | 90.0098 | 0.00135495 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.268Z | Extended Element | 5333607.4132030141,2184676.8534873235,360.33018729107147 | 90.8532 | 90.0098 | 0.00135375 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.290Z | Extended Element | 5333607.4082781412,2184677.1836502911,359.70495657439426 | 90.8532 | 90.0098 | 0.00135609 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.313Z | Extended Element | 5333607.4132030131,2184676.8534873249,360.00975718345859 | 90.8532 | 90.0098 | 0.00135494 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.339Z | Extended Element | 5333607.4082781421,2184677.1836502925,359.46170028800788 | 90.8532 | 90.0098 | 0.00135701 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.365Z | Extended Element | 5333607.4132030169,2184676.8534873254,359.70495657389512 | 90.8532 | 90.0098 | 0.00135608 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.390Z | Extended Element | 5333607.408278143,2184677.1836502925,359.218444001693 | 90.8532 | 90.0098 | 0.00135791 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.415Z | Extended Element | 5333607.4132030187,2184676.8534873258,359.46170028729034 | 90.8532 | 90.0098 | 0.00135699 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.440Z | Extended Element | 5333607.4132030187,2184676.8534873258,359.21844400123138 | 90.8532 | 90.0098 | 0.00135792 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.464Z | Extended Element | 5333605.6554916846,2184677.182844223,360.93929741466837 | -94.8384 | -90.0079 | -0.00159454 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.490Z | Extended Element | 5333605.6554916883,2184677.1828442249,360.6188673179621 | -94.8384 | -90.0079 | -0.00159593 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.514Z | Extended Element | 5333545.2787336856,2184676.2600705735,360.89742365084265 | -89.1455 | -90.0098 | -0.0000766129 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.541Z | Extended Element | 5333545.2808409529,2184676.1187997041,360.91496634045757 | -89.1455 | -90.0098 | -0.0000765981 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.567Z | Extended Element | 5333545.2834199071,2184675.9459068445,360.89742365183986 | -89.1455 | -90.0098 | -0.000076624 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.594Z | Extended Element | 5333545.2787336865,2184676.2600705726,360.57699354309153 | -89.1455 | -90.0098 | -0.000076681 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.620Z | Extended Element | 5333545.2808409529,2184676.1187997032,360.59453620836962 | -89.1455 | -90.0098 | -0.0000766884 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.645Z | Extended Element | 5333545.2834199071,2184675.9459068431,360.57699354428644 | -89.1455 | -90.0098 | -0.000076681 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.671Z | Extended Element | 5333545.2808409529,2184676.1187997027,360.256563435874 | -89.1455 | -90.0098 | -0.0000767603 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.697Z | Extended Element | 5333545.2836585594,2184675.9299076046,360.25656343641839 | -89.1455 | -90.0098 | -0.0000767603 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.724Z | Extended Element | 5333545.2787336865,2184676.2600705712,359.93613332811623 | -89.1455 | -90.0098 | -0.0000768286 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.752Z | Extended Element | 5333545.2787336856,2184676.2600705689,359.63133271855258 | -89.1455 | -90.0098 | -0.0000768826 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.779Z | Extended Element | 5333545.2836585594,2184675.9299076041,359.93613332912912 | -89.1455 | -90.0098 | -0.0000768175 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.807Z | Extended Element | 5333545.2787336865,2184676.2600705689,359.38807643194809 | -89.1455 | -90.0098 | -0.0000769347 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.831Z | Extended Element | 5333545.2836585594,2184675.9299076032,359.63133271957179 | -89.1455 | -90.0098 | -0.0000768715 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.858Z | Extended Element | 5333545.2787336856,2184676.2600705675,359.14482014588901 | -89.1455 | -90.0098 | -0.0000769868 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.887Z | Extended Element | 5333545.2836585594,2184675.9299076023,359.38807643318535 | -89.1455 | -90.0098 | -0.0000769346 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.909Z | Extended Element | 5333545.2836585585,2184675.9299076018,359.14482014687064 | -89.1455 | -90.0098 | -0.0000769868 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.936Z | Extended Element | 5333545.2787336856,2184676.2600705712,360.25656343572922 | -89.1455 | -90.0098 | -0.0000767492 | -0.0079375000000000018,2.0113588567784948e-10,-0.0079375004060202071 | 0.0079375002384184639,1.7526035053400371,0.0079374998323983835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.961Z | Extended Element | 5333547.0308117121,2184676.3083694372,360.86567355775622 | 96.546 | 90.0132 | -0.00000312665 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:06.989Z | Extended Element | 5333547.0308117112,2184676.3083694368,360.54524345020258 | 96.546 | 90.0132 | -0.00000311757 | -0.0079375000000000018,5.2665721249115843e-10,-0.007937500047565639 | 0.0079375000000000018,1.2192024388811493,0.0079374999524343924
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.016Z | Extended Element | 5333613.1484818412,2184691.1646474255,360.93973006247705 | 90.8547 | 90.0098 | -0.00007034 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.046Z | Extended Element | 5333613.1484818431,2184691.1646474274,360.61929995488248 | 90.8547 | 90.0098 | -0.0000704025 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.076Z | Extended Element | 5333613.1484818431,2184691.1646474283,360.29886984728768 | 90.8547 | 90.0098 | -0.0000704747 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.100Z | Extended Element | 5333613.1484818431,2184691.1646474311,359.97843973969321 | 90.8547 | 90.0098 | -0.0000705278 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.127Z | Extended Element | 5333613.1484818431,2184691.1646474325,359.67363913009194 | 90.8547 | 90.0098 | -0.0000705972 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.151Z | Extended Element | 5333613.148481844,2184691.1646474339,359.43038284371147 | 90.8547 | 90.0098 | -0.000070645 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.174Z | Extended Element | 5333613.148481844,2184691.1646474316,359.18712655736368 | 90.8547 | 90.0098 | -0.0000707024 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.200Z | Extended Element | 5333613.1534067169,2184690.834484465,359.18712655632396 | 90.8547 | 90.0098 | -0.0000706928 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.226Z | Extended Element | 5333613.1534067169,2184690.8344844673,359.43038284267146 | 90.8547 | 90.0098 | -0.0000706449 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.250Z | Extended Element | 5333613.1534067169,2184690.8344844654,359.67363912905211 | 90.8547 | 90.0098 | -0.0000706068 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.275Z | Extended Element | 5333613.1534067169,2184690.8344844645,359.97843973865344 | 90.8547 | 90.0098 | -0.0000705374 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.303Z | Extended Element | 5333613.1534067169,2184690.8344844631,360.29886984624807 | 90.8547 | 90.0098 | -0.0000704651 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.328Z | Extended Element | 5333613.1534067178,2184690.8344844608,360.61929995384253 | 90.8547 | 90.0098 | -0.0000704025 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.355Z | Extended Element | 5333613.1534067178,2184690.8344844594,360.93973006143722 | 90.8547 | 90.0098 | -0.00007034 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.386Z | Extended Element | 5333611.1192829069,2184690.9962519454,360.95727274278414 | 0.859925 | 90 | -90.0053 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.413Z | Extended Element | 5333611.1192829087,2184690.9962519458,360.63684261069636 | 1.27247 | 90 | -90.4179 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.441Z | Extended Element | 5333608.4749616049,2184677.1995614702,360.95517247903462 | 90.8533 | 90.0098 | 0.00126675 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.462Z | Extended Element | 5333608.4749616059,2184677.1995614707,360.63474237143981 | 90.8533 | 90.0098 | 0.00126786 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.484Z | Extended Element | 5333608.4749616068,2184677.1995614725,360.31431226384535 | 90.8533 | 90.0098 | 0.001269 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.509Z | Extended Element | 5333608.4749616105,2184677.1995614734,359.99388215625083 | 90.8533 | 90.0098 | 0.00127012 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.536Z | Extended Element | 5333608.4749616105,2184677.1995614744,359.68908154664945 | 90.8533 | 90.0098 | 0.00127119 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.560Z | Extended Element | 5333608.4749616105,2184677.1995614748,359.44582526026892 | 90.8533 | 90.0098 | 0.00127205 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.586Z | Extended Element | 5333608.4749616114,2184677.199561473,359.20256897392136 | 90.8533 | 90.0098 | 0.00127293 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.613Z | Extended Element | 5333608.4798864881,2184676.8693985068,359.20256897340136 | 90.8533 | 90.0098 | 0.00127292 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.639Z | Extended Element | 5333608.4798864871,2184676.8693985092,359.44582525974914 | 90.8533 | 90.0098 | 0.00127206 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.663Z | Extended Element | 5333608.4798864862,2184676.8693985078,359.6890815461295 | 90.8533 | 90.0098 | 0.00127119 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.690Z | Extended Element | 5333608.4798864853,2184676.8693985078,359.99388215573083 | 90.8533 | 90.0098 | 0.00127013 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.716Z | Extended Element | 5333608.4798864834,2184676.8693985064,360.31431226332535 | 90.8533 | 90.0098 | 0.00126899 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.743Z | Extended Element | 5333608.4798864825,2184676.8693985054,360.63474237092009 | 90.8533 | 90.0098 | 0.00126787 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.770Z | Extended Element | 5333608.4798864787,2184676.8693985045,360.95517247851478 | 90.8533 | 90.0098 | 0.00126674 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.796Z | Extended Element | 5333606.4465203676,2184676.980370108,360.97271515996709 | 21.7117 | -90 | 110.857 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.820Z | Extended Element | 5333606.4465203676,2184676.9803701076,360.6522850278792 | 21.7011 | -90 | 110.847 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.849Z | Extended Element | 5333544.2120502163,2184676.2441593925,360.88154861890331 | -89.1454 | -90.0098 | 0.00000806035 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.876Z | Extended Element | 5333544.2120502153,2184676.2441593902,360.56111851130873 | -89.1454 | -90.0098 | 0.00000807709 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.904Z | Extended Element | 5333544.2120502153,2184676.2441593893,360.24068840371416 | -89.1454 | -90.0098 | 0.00000808427 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.926Z | Extended Element | 5333544.2120502153,2184676.2441593879,359.92025829611953 | -89.1454 | -90.0098 | 0.00000808187 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.951Z | Extended Element | 5333544.2120502163,2184676.2441593865,359.61545768651837 | -89.1454 | -90.0098 | 0.00000808872 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:07.978Z | Extended Element | 5333544.2120502172,2184676.2441593846,359.37220140013773 | -89.1454 | -90.0098 | 0.0000080942 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.007Z | Extended Element | 5333544.2120502172,2184676.244159387,359.12894511379005 | -89.1454 | -90.0098 | 0.00000809968 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.031Z | Extended Element | 5333544.2169750901,2184675.9139964208,359.12894511483 | -89.1454 | -90.0098 | 0.00000809968 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.059Z | Extended Element | 5333544.216975091,2184675.913996418,359.37220140117762 | -89.1454 | -90.0098 | 0.00000810381 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.085Z | Extended Element | 5333544.2169750901,2184675.9139964199,359.61545768755815 | -89.1454 | -90.0098 | 0.00000809833 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.111Z | Extended Element | 5333544.2169750901,2184675.9139964217,359.92025829715936 | -89.1454 | -90.0098 | 0.00000808187 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.137Z | Extended Element | 5333544.2169750901,2184675.9139964231,360.24068840475383 | -89.1454 | -90.0098 | 0.00000806509 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.163Z | Extended Element | 5333544.2169750892,2184675.9139964236,360.56111851234846 | -89.1454 | -90.0098 | 0.00000806751 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.190Z | Extended Element | 5333544.2169750892,2184675.9139964255,360.88154861994315 | -89.1454 | -90.0098 | 0.00000806034 | -0.0079375002384769258,-1.3191819376542848e-10,-0.007937499873374821 | 0.0079375000000002274,2.0320040663390926,0.0079375003650442207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.214Z | Extended Element | 5333546.2461740263,2184676.0823919075,360.89909130025029 | 1.3363 | 90 | 89.5183 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.241Z | Extended Element | 5333546.2461740253,2184676.082391907,360.57866116816245 | 1.74891 | 90 | 89.1057 | -0.0093330072323268877,-1.8496397611800956e-10,-0.0093330087981743724 | 0.0093330077092808744,2.0314491579895431,0.074383527506903482
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.265Z | Extended Element | 5333606.4683203362,2184677.1870938907,360.98057252175312 | 112.274 | -7.6545e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.291Z | Extended Element | 5333606.7513179937,2184677.1913152235,360.98057252288567 | 112.274 | -7.6545e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.317Z | Extended Element | 5333607.0343156504,2184677.1955365576,360.98057252401821 | 112.274 | -7.65449e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.343Z | Extended Element | 5333607.3173133042,2184677.1997578903,360.98057252515088 | 112.274 | 3.67061e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.368Z | Extended Element | 5333607.6003109589,2184677.203979224,360.98057252628342 | 112.274 | -2.14789e-08 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.394Z | Extended Element | 5333607.8833086155,2184677.2082005581,360.98057252741603 | 112.274 | -2.14789e-08 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.420Z | Extended Element | 5333608.1663062721,2184677.2124218908,360.98057252854863 | 112.274 | 6.16991e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.450Z | Extended Element | 5333608.4493039278,2184677.2166432249,360.98057252968113 | 112.274 | -7.65447e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.479Z | Extended Element | 5333606.4732452137,2184676.8569309241,360.98057252146828 | 112.274 | -7.65449e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.509Z | Extended Element | 5333606.7562428704,2184676.8611522578,360.98057252260094 | 112.274 | 3.67061e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.534Z | Extended Element | 5333607.0392405242,2184676.8653735905,360.98057252373349 | 112.274 | -2.14789e-08 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.560Z | Extended Element | 5333607.3222381817,2184676.8695949242,360.98057252486615 | 112.274 | -7.65448e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.588Z | Extended Element | 5333607.6052358365,2184676.8738162578,360.9805725259987 | 112.274 | 6.16991e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.615Z | Extended Element | 5333607.8882334931,2184676.8780375919,360.9805725271313 | 112.274 | 6.16992e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.646Z | Extended Element | 5333608.1712311488,2184676.8822589251,360.98057252826385 | 112.274 | -1.01538e-08 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.676Z | Extended Element | 5333608.4542288063,2184676.8864802588,360.98057252939645 | 112.274 | -7.65446e-09 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.701Z | Extended Element | 5333611.1418405753,2184691.1521798451,360.96513011325266 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.726Z | Extended Element | 5333611.4248382319,2184691.1564011802,360.96513011325266 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.759Z | Extended Element | 5333611.7078358857,2184691.1606225125,360.96513011325266 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.784Z | Extended Element | 5333611.9908335423,2184691.1648438461,360.96513011325266 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.811Z | Extended Element | 5333612.2738311989,2184691.1690651802,360.96513011325266 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.837Z | Extended Element | 5333612.5568288546,2184691.173286513,360.96513011325266 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.862Z | Extended Element | 5333612.8398265094,2184691.1775078462,360.96513011325266 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.889Z | Extended Element | 5333613.122824166,2184691.1817291789,360.96513011325266 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.913Z | Extended Element | 5333611.1467654509,2184690.8220168799,360.96513011244809 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.940Z | Extended Element | 5333611.4297631066,2184690.8262382136,360.96513011244809 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:08.980Z | Extended Element | 5333611.7127607623,2184690.8304595458,360.96513011244809 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.005Z | Extended Element | 5333611.995758418,2184690.8346808795,360.96513011244809 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.030Z | Extended Element | 5333612.2787560746,2184690.8389022136,360.96513011244809 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.056Z | Extended Element | 5333612.5617537322,2184690.8431235468,360.96513011244809 | 112.274 | 1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.082Z | Extended Element | 5333612.844751386,2184690.8473448819,360.96513011244809 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.108Z | Extended Element | 5333613.1277490426,2184690.8515662146,360.96513011244809 | 112.274 | 1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.132Z | Extended Element | 5333544.2377078906,2184676.2270776383,360.9069486699143 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.153Z | Extended Element | 5333544.5207055463,2184676.231298971,360.9069486699143 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.177Z | Extended Element | 5333544.803703201,2184676.2355203046,360.9069486699143 | 112.275 | -1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.200Z | Extended Element | 5333545.0867008595,2184676.2397416392,360.9069486699143 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.227Z | Extended Element | 5333545.3696985142,2184676.243962972,360.9069486699143 | 112.275 | -1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.252Z | Extended Element | 5333545.652696169,2184676.2481843052,360.9069486699143 | 112.275 | -1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.278Z | Extended Element | 5333545.9356938256,2184676.2524056388,360.9069486699143 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.302Z | Extended Element | 5333546.2186914813,2184676.2566269729,360.9069486699143 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.328Z | Extended Element | 5333544.2426327681,2184675.8969146726,360.90694867071892 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.355Z | Extended Element | 5333544.5256304238,2184675.9011360048,360.90694867071892 | 112.275 | -1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.379Z | Extended Element | 5333544.8086280786,2184675.905357339,360.90694867071892 | 112.275 | -1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.405Z | Extended Element | 5333545.0916257352,2184675.9095786721,360.90694867071892 | 112.275 | -1.65892e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.429Z | Extended Element | 5333545.3746233918,2184675.9138000067,360.90694867071892 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.457Z | Extended Element | 5333545.6576210475,2184675.9180213399,360.90694867071892 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.482Z | Extended Element | 5333545.9406187041,2184675.922242674,360.90694867071892 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.508Z | Extended Element | 5333546.2236163598,2184675.9264640072,360.90694867071892 | 112.275 | -1.79717e-07 | -90 | -0.0095249999999999987,0,-0.0095250003492459677 | 0.0095249999999999987,1.8288036576075248,0.0095249996507540367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.535Z | Extended Element | 5333610.4110764293,2184690.9682223382,360.1777285264929 | -179.144 | -0.000056624 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.562Z | Extended Element | 5333610.6396514596,2184690.9716318776,360.17772852652968 | -179.144 | -0.0000566669 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.588Z | Extended Element | 5333610.8682264872,2184690.9750414155,360.17772852656623 | -179.144 | -0.0000567115 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.613Z | Extended Element | 5333611.0968015166,2184690.9784509554,360.17772852660289 | -179.144 | -0.0000565811 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.638Z | Extended Element | 5333611.3253765479,2184690.9818604933,360.17772852663973 | -179.144 | -0.0000566682 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.664Z | Extended Element | 5333611.5539515764,2184690.9852700317,360.17772852667622 | -179.144 | -0.0000566669 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.689Z | Extended Element | 5333611.7825266067,2184690.9886795711,360.17772852671294 | -179.144 | -0.000056625 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.713Z | Extended Element | 5333612.0111016361,2184690.992089109,360.17772852674966 | -179.144 | -0.0000566669 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.743Z | Extended Element | 5333612.2396766646,2184690.9954986474,360.17772852678621 | -179.144 | -0.0000566673 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.768Z | Extended Element | 5333612.39206002,2184690.9977716743,360.17772852681077 | -179.144 | -0.0000566676 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.794Z | Extended Element | 5333612.5444433764,2184691.0000446998,360.17772852683515 | -179.144 | -0.000056624 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.818Z | Extended Element | 5333612.696826729,2184691.0023177257,360.17772852685965 | -179.144 | -0.000056624 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.844Z | Extended Element | 5333605.7397819534,2184676.8539276854,360.19317094369961 | -179.144 | -0.0000568393 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.871Z | Extended Element | 5333605.9683569837,2184676.8573372248,360.19317094461439 | -179.144 | -0.0000569251 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.896Z | Extended Element | 5333606.1969320131,2184676.8607467632,360.19317094552923 | -179.144 | -0.0000569696 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.922Z | Extended Element | 5333606.4255070435,2184676.8641563025,360.19317094644413 | -179.144 | -0.0000568393 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.944Z | Extended Element | 5333606.654082072,2184676.86756584,360.19317094735874 | -179.144 | -0.0000568835 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.969Z | Extended Element | 5333606.8826571014,2184676.8709753798,360.19317094827352 | -179.144 | -0.0000569251 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:09.996Z | Extended Element | 5333607.1112321327,2184676.8743849187,360.19317094918841 | -179.144 | -0.0000568399 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:10.019Z | Extended Element | 5333607.3398071621,2184676.8777944567,360.19317095010314 | -179.144 | -0.0000569257 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:10.043Z | Extended Element | 5333607.5683821915,2184676.881203996,360.19317095101792 | -179.144 | -0.0000569254 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:10.067Z | Extended Element | 5333607.7207655441,2184676.8834770215,360.19317095162779 | -179.144 | -0.0000568828 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:10.090Z | Extended Element | 5333607.8731489014,2184676.8857500474,360.19317095223755 | -179.144 | -0.0000569251 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:13:10.113Z | Extended Element | 5333608.0255322549,2184676.8880230733,360.19317095284748 | -179.144 | -0.0000569248 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
