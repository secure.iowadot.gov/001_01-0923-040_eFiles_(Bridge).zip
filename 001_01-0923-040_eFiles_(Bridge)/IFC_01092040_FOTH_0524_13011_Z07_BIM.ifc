Properties of the parts of a building model (IFC4X3_ADD2), part 8 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.192Z | Extended Element | 5333553.0331459092,2184676.0899567604,361.01278285975934 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.202Z | Extended Element | 5333553.337909664,2184676.0945027689,361.01412396945989 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.212Z | Extended Element | 5333553.6426734189,2184676.0990487761,361.01546507916026 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.223Z | Extended Element | 5333553.9474371755,2184676.1035947842,361.0168061888607 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.235Z | Extended Element | 5333554.2522009322,2184676.1081407927,361.01814729856119 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.244Z | Extended Element | 5333554.5569646871,2184676.1126867998,361.01948840826157 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.261Z | Extended Element | 5333554.8617285416,2184676.1172328093,361.02080698458781 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.270Z | Extended Element | 5333555.1664924035,2184676.1217788183,361.02212378615548 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.279Z | Extended Element | 5333555.4712562654,2184676.1263248269,361.02344058772303 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.296Z | Extended Element | 5333555.7760201814,2184676.1308708382,361.02474466579878 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.306Z | Extended Element | 5333556.0807842826,2184676.1354168509,361.026004347585 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.317Z | Extended Element | 5333556.3855483877,2184676.1399628636,361.02726402937111 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.326Z | Extended Element | 5333556.6903124889,2184676.1445088759,361.02852371115716 | -179.145 | -1.72678e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.338Z | Extended Element | 5333556.9950765949,2184676.1490548891,361.02978339294339 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.356Z | Extended Element | 5333557.2998407548,2184676.1536009023,361.03102845985461 | -179.145 | -1.73144e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.366Z | Extended Element | 5333557.6046051215,2184676.1581469192,361.03222251826213 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.377Z | Extended Element | 5333557.9093694901,2184676.1626929366,361.03341657666977 | -179.145 | 1.42178e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.388Z | Extended Element | 5333558.2141338568,2184676.1672389531,361.03461063507734 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.399Z | Extended Element | 5333558.5188982217,2184676.1717849704,361.03580469348492 | -179.145 | 1.42178e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.417Z | Extended Element | 5333558.823662647,2184676.1763309874,361.0369841394986 | -179.145 | -1.72678e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.426Z | Extended Element | 5333559.1284272643,2184676.1808770085,361.03811257436206 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.438Z | Extended Element | 5333559.4331918797,2184676.1854230291,361.03924100922558 | -179.145 | 1.42178e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.449Z | Extended Element | 5333559.7379564987,2184676.1899690498,361.04036944408909 | -179.145 | -1.73144e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.460Z | Extended Element | 5333560.0427211151,2184676.1945150709,361.04149787895273 | -179.145 | -1.11621e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.476Z | Extended Element | 5333560.3474857872,2184676.1990610925,361.04261170363543 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.488Z | Extended Element | 5333560.6522506382,2184676.2036071159,361.04367451479635 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.496Z | Extended Element | 5333560.957015492,2184676.2081531403,361.04473732595704 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.507Z | Extended Element | 5333561.2617803439,2184676.2126991637,361.04580013711808 | -179.145 | 1.46836e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.520Z | Extended Element | 5333561.5665451977,2184676.2172451881,361.04686294827883 | -179.145 | 1.32862e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.538Z | Extended Element | 5333561.8713101018,2184676.2217912138,361.04791115122168 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.549Z | Extended Element | 5333562.1760751763,2184676.2263372405,361.0489083385346 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.559Z | Extended Element | 5333562.4808402508,2184676.2308832682,361.04990552584763 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.571Z | Extended Element | 5333562.7856053254,2184676.2354292958,361.05090271316061 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.580Z | Extended Element | 5333563.0903704008,2184676.239975323,361.0518999004737 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.599Z | Extended Element | 5333563.3951355219,2184676.2445213511,361.05288248129273 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.607Z | Extended Element | 5333563.699900805,2184676.2490673815,361.05381404461565 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.619Z | Extended Element | 5333564.0046660872,2184676.2536134119,361.0547456079388 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.627Z | Extended Element | 5333564.3094313685,2184676.2581594419,361.055677171262 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.638Z | Extended Element | 5333564.6141966507,2184676.2627054732,361.05660873458498 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.657Z | Extended Element | 5333564.9189619776,2184676.2672515037,361.05752569291894 | -179.145 | -4.91676e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.669Z | Extended Element | 5333565.2237274516,2184676.2717975373,361.05839163212624 | -179.145 | -1.73144e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.678Z | Extended Element | 5333565.5284929303,2184676.2763435715,361.05925757133349 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.690Z | Extended Element | 5333565.8332584053,2184676.2808896047,361.06012351054073 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.701Z | Extended Element | 5333566.1380238812,2184676.2854356379,361.06098944974792 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.721Z | Extended Element | 5333566.4427893981,2184676.2899816721,361.06184078526269 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.730Z | Extended Element | 5333566.7475550519,2184676.2945277081,361.06264110023113 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.744Z | Extended Element | 5333567.0523207057,2184676.2990737441,361.06344141519958 | -179.145 | 1.46836e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.753Z | Extended Element | 5333567.3570863632,2184676.3036197796,361.06424173016791 | -179.145 | -4.73044e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.766Z | Extended Element | 5333567.6618520189,2184676.3081658157,361.06504204513629 | -179.145 | -4.73044e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.784Z | Extended Element | 5333567.9666177081,2184676.3127118526,361.06582775751866 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.793Z | Extended Element | 5333568.2713835305,2184676.3172578914,361.0665624481378 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.802Z | Extended Element | 5333568.5761493519,2184676.3218039307,361.06729713875689 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.812Z | Extended Element | 5333568.8809151715,2184676.326349969,361.06803182937597 | -179.145 | 1.3752e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.823Z | Extended Element | 5333569.185680992,2184676.3308960074,361.06876651999511 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.840Z | Extended Element | 5333569.4904468479,2184676.3354420457,361.0694866089587 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.850Z | Extended Element | 5333569.7952128192,2184676.3399880868,361.07015567512627 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.859Z | Extended Element | 5333570.0999787906,2184676.3445341275,361.07082474129396 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.869Z | Extended Element | 5333570.4047447601,2184676.3490801691,361.07149380746154 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.878Z | Extended Element | 5333570.7095107343,2184676.3536262098,361.07216287362922 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.895Z | Extended Element | 5333571.0142767355,2184676.3581722504,361.07281733891125 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.905Z | Extended Element | 5333571.3190428447,2184676.3627182934,361.07342078053426 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.913Z | Extended Element | 5333571.623808952,2184676.367264336,361.07402422215739 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.924Z | Extended Element | 5333571.9285750622,2184676.3718103794,361.07462766378057 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.934Z | Extended Element | 5333572.2333411686,2184676.376356421,361.07523110540376 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.952Z | Extended Element | 5333572.5381073058,2184676.3809024654,361.07581994676553 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.962Z | Extended Element | 5333572.842873537,2184676.3854485098,361.07635776376054 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.973Z | Extended Element | 5333573.1476397663,2184676.3899945542,361.07689558075549 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.985Z | Extended Element | 5333573.4524060022,2184676.3945405995,361.0774333977505 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:23.994Z | Extended Element | 5333573.7571722316,2184676.3990866444,361.07797121474533 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.011Z | Extended Element | 5333574.0619384861,2184676.4036326897,361.07849443197301 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.023Z | Extended Element | 5333574.3667048272,2184676.4081787355,361.07896662426424 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.033Z | Extended Element | 5333574.6714711674,2184676.4127247818,361.07943881655541 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.043Z | Extended Element | 5333574.9762375085,2184676.4172708285,361.07991100884664 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.054Z | Extended Element | 5333575.2810038459,2184676.4218168738,361.08038320113786 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.068Z | Extended Element | 5333575.5857702084,2184676.4263629206,361.08084079404142 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.077Z | Extended Element | 5333575.8905366445,2184676.4309089691,361.08124736156424 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.089Z | Extended Element | 5333576.1953030778,2184676.4354550163,361.08165392908728 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.100Z | Extended Element | 5333576.500069513,2184676.440001064,361.08206049661027 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.109Z | Extended Element | 5333576.8048359482,2184676.4445471116,361.08246706413325 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.128Z | Extended Element | 5333577.109602402,2184676.4490931593,361.08285903254739 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.139Z | Extended Element | 5333577.4143689144,2184676.4536392083,361.0831999752445 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.151Z | Extended Element | 5333577.7191354316,2184676.4581852569,361.08354091794155 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.160Z | Extended Element | 5333578.0239019468,2184676.4627313064,361.08388186063871 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.172Z | Extended Element | 5333578.3286684621,2184676.4672773546,361.08422280333582 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.191Z | Extended Element | 5333578.6334349923,2184676.4718234045,361.08454914711882 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.202Z | Extended Element | 5333578.9382015746,2184676.4763694545,361.08482446494321 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.212Z | Extended Element | 5333579.2429681541,2184676.480915505,361.08509978276743 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.223Z | Extended Element | 5333579.5477347374,2184676.4854615536,361.0853751005917 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.236Z | Extended Element | 5333579.852501316,2184676.490007604,361.08565041841592 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.256Z | Extended Element | 5333580.1572679104,2184676.494553654,361.08591113745166 | -179.145 | -4.91676e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.267Z | Extended Element | 5333580.4620345449,2184676.4990997049,361.08612083036473 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.277Z | Extended Element | 5333580.7668011794,2184676.5036457554,361.08633052327792 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.289Z | Extended Element | 5333581.0715678111,2184676.5081918063,361.086540216191 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.300Z | Extended Element | 5333581.3763344456,2184676.5127378567,361.08674990910413 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.318Z | Extended Element | 5333581.6811010893,2184676.5172839072,361.08694500329977 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.328Z | Extended Element | 5333581.9858677601,2184676.5218299581,361.08708907127266 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.339Z | Extended Element | 5333582.2906344328,2184676.5263760099,361.08723313924543 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.350Z | Extended Element | 5333582.5954011055,2184676.5309220613,361.08737720721831 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.360Z | Extended Element | 5333582.9001677772,2184676.5354681117,361.08752127519114 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.380Z | Extended Element | 5333583.2049344545,2184676.5400141636,361.08765074447876 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.391Z | Extended Element | 5333583.5097011505,2184676.5445602145,361.08772918749128 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.402Z | Extended Element | 5333583.8144678446,2184676.5491062663,361.08780763050379 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.412Z | Extended Element | 5333584.1192345414,2184676.5536523173,361.08788607351619 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.424Z | Extended Element | 5333584.4240012374,2184676.55819837,361.0879645165287 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.442Z | Extended Element | 5333584.7287679343,2184676.562744421,361.088030584808 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.453Z | Extended Element | 5333585.0335346404,2184676.5672904733,361.08805340007206 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.462Z | Extended Element | 5333585.3383013448,2184676.5718365246,361.08807621533612 | -179.145 | 1.46836e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.474Z | Extended Element | 5333585.64306805,2184676.5763825765,361.08809903060012 | -179.145 | -1.72678e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.492Z | Extended Element | 5333585.9478347553,2184676.5809286279,361.08809737289863 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.509Z | Extended Element | 5333586.2526014596,2184676.5854746797,361.08807785239412 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.521Z | Extended Element | 5333586.5573681612,2184676.5900207316,361.08802504546242 | -179.145 | 1.42178e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.530Z | Extended Element | 5333586.8621348627,2184676.5945667834,361.08797223853065 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.541Z | Extended Element | 5333587.1669015633,2184676.5991128348,361.08791943159889 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.553Z | Extended Element | 5333587.4716682658,2184676.6036588876,361.08786662466702 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.573Z | Extended Element | 5333587.7764349645,2184676.6082049389,361.08779921906523 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.585Z | Extended Element | 5333588.0812016455,2184676.6127509903,361.08768078716776 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.594Z | Extended Element | 5333588.3859683285,2184676.6172970408,361.08756235527034 | -179.145 | -1.09758e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.605Z | Extended Element | 5333588.6907350123,2184676.6218430921,361.0874439233728 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.615Z | Extended Element | 5333588.9955016952,2184676.626389144,361.08732549147533 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.629Z | Extended Element | 5333589.3002683688,2184676.6309351954,361.08719246093631 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.640Z | Extended Element | 5333589.6050350219,2184676.6354812467,361.0870084040896 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.650Z | Extended Element | 5333589.9098016704,2184676.6400272972,361.08682434724301 | -179.145 | -1.73144e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.660Z | Extended Element | 5333590.2145683207,2184676.6445733481,361.0866402903963 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.671Z | Extended Element | 5333590.519334971,2184676.6491194,361.08645623354965 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.689Z | Extended Element | 5333590.8241016101,2184676.6536654504,361.086257578127 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.698Z | Extended Element | 5333591.1288682157,2184676.6582115008,361.08600789635665 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.710Z | Extended Element | 5333591.4336348195,2184676.6627575504,361.08575821458641 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.721Z | Extended Element | 5333591.7384014213,2184676.6673036003,361.08550853281611 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.731Z | Extended Element | 5333592.0431680242,2184676.6718496503,361.08525885104586 | -179.145 | 1.3752e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.752Z | Extended Element | 5333592.3479346167,2184676.6763957012,361.08499457081734 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.763Z | Extended Element | 5333592.652701159,2184676.6809417498,361.08467926415807 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.775Z | Extended Element | 5333592.9574677004,2184676.6854877989,361.08436395749868 | -179.145 | -1.09758e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.786Z | Extended Element | 5333593.2622342426,2184676.6900338475,361.08404865083929 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.795Z | Extended Element | 5333593.5670007886,2184676.6945798984,361.08373334417996 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.814Z | Extended Element | 5333593.8717673114,2184676.6991259465,361.08340343924772 | -179.145 | 1.46836e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.824Z | Extended Element | 5333594.176533781,2184676.7036719951,361.08302250774375 | -179.145 | 1.42178e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.835Z | Extended Element | 5333594.4813002497,2184676.7082180437,361.08264157623972 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.843Z | Extended Element | 5333594.7860667175,2184676.7127640918,361.08226064473564 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.855Z | Extended Element | 5333595.0908331862,2184676.7173101399,361.08187971323161 | -179.145 | -1.73144e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.873Z | Extended Element | 5333595.3955996316,2184676.7218561866,361.08148418372275 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.885Z | Extended Element | 5333595.7003660118,2184676.7264022348,361.08103762742593 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.894Z | Extended Element | 5333596.0051323902,2184676.7309482815,361.08059107112928 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.904Z | Extended Element | 5333596.3098987704,2184676.7354943282,361.08014451483257 | -179.145 | 1.42178e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.913Z | Extended Element | 5333596.6146651478,2184676.7400403749,361.07969795853569 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.929Z | Extended Element | 5333596.9194315029,2184676.7445864221,361.07923680460033 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.941Z | Extended Element | 5333597.2241977798,2184676.749132467,361.07872462357454 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.952Z | Extended Element | 5333597.5289640557,2184676.7536785123,361.07821244254876 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.961Z | Extended Element | 5333597.8337303316,2184676.7582245576,361.07770026152303 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.972Z | Extended Element | 5333598.1384966057,2184676.7627706029,361.07718808049731 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.988Z | Extended Element | 5333598.4432628565,2184676.7673166483,361.07666130231172 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:24.997Z | Extended Element | 5333598.7480290132,2184676.7718626922,361.07608349662621 | -179.145 | 1.3752e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.007Z | Extended Element | 5333599.0527951736,2184676.7764087357,361.07550569094059 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.017Z | Extended Element | 5333599.3575613303,2184676.7809547787,361.07492788525497 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.027Z | Extended Element | 5333599.6623274898,2184676.7855008226,361.07435007956934 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.042Z | Extended Element | 5333599.9670936177,2184676.7900468656,361.07375767733168 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.052Z | Extended Element | 5333600.2718596449,2184676.7945929077,361.0731142470683 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.061Z | Extended Element | 5333600.5766256731,2184676.7991389488,361.07247081680487 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.073Z | Extended Element | 5333600.8813916985,2184676.8036849909,361.07182738654149 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.085Z | Extended Element | 5333601.1861577258,2184676.808231032,361.07118395627805 | -179.145 | -1.1069e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.102Z | Extended Element | 5333601.4909237195,2184676.8127770736,361.07052593021336 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.112Z | Extended Element | 5333601.7956896005,2184676.8173231129,361.06981687546096 | -179.145 | -4.73044e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.123Z | Extended Element | 5333602.1004554834,2184676.8218691521,361.06910782070872 | -179.145 | -4.77702e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.135Z | Extended Element | 5333602.4052213645,2184676.8264151919,361.06839876595643 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.146Z | Extended Element | 5333602.7099872446,2184676.8309612307,361.06768971120414 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.163Z | Extended Element | 5333603.0147530893,2184676.8355072699,361.06696606156038 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.174Z | Extended Element | 5333603.3195188129,2184676.8400533074,361.06619138241729 | -179.145 | -4.8236e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.184Z | Extended Element | 5333603.6242845347,2184676.8445993438,361.06541670327425 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.193Z | Extended Element | 5333603.9290502556,2184676.8491453812,361.06464202413133 | -179.145 | 1.42178e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.202Z | Extended Element | 5333604.2338159773,2184676.8536914177,361.06386734498841 | -179.145 | -1.10224e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.218Z | Extended Element | 5333604.5385816582,2184676.8582374542,361.06307807203763 | -179.145 | -1.09758e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.228Z | Extended Element | 5333604.8433472067,2184676.8627834888,361.06223776861276 | -179.145 | -1.09758e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.240Z | Extended Element | 5333605.1481127543,2184676.8673295234,361.06139746518789 | -179.145 | -1.11156e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.250Z | Extended Element | 5333605.4528783038,2184676.871875558,361.06055716176303 | -179.145 | -4.87018e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.276Z | Extended Element | 5333547.2440580456,2184677.0790394251,360.76045609832642 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.287Z | Extended Element | 5333547.5488218013,2184677.0835854337,360.76179720803043 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.297Z | Extended Element | 5333547.8535855589,2184677.0881314413,360.76313831772814 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.307Z | Extended Element | 5333548.1583493128,2184677.0926774493,360.76447942742988 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.318Z | Extended Element | 5333548.4631130695,2184677.0972234569,360.76582053713139 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.327Z | Extended Element | 5333548.7678768253,2184677.1017694646,360.76716164683154 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.339Z | Extended Element | 5333549.072640582,2184677.1063154722,360.76850275653123 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.348Z | Extended Element | 5333549.3774043377,2184677.1108614802,360.7698438662311 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.359Z | Extended Element | 5333549.6821680926,2184677.1154074869,360.77118497593352 | -179.145 | 3.91513e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.370Z | Extended Element | 5333549.9869318474,2184677.1199534959,360.77252608563236 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.379Z | Extended Element | 5333550.2916956032,2184677.1244995031,360.77386719533359 | -179.145 | 3.24244e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.390Z | Extended Element | 5333550.5964593599,2184677.1290455111,360.77520830503357 | -179.145 | 4.02262e-09 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.401Z | Extended Element | 5333550.9012231175,2184677.1335915187,360.77654941473554 | -179.145 | 1.8436e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.411Z | Extended Element | 5333551.2059868742,2184677.1381375259,360.77789052443546 | -179.145 | 1.83285e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.422Z | Extended Element | 5333551.5107506281,2184677.1426835344,360.77923163413487 | -179.145 | -8.61703e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.431Z | Extended Element | 5333551.815514382,2184677.1472295416,360.7805727438361 | -179.145 | -8.69505e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:25.442Z | Extended Element | 5333552.1202781396,2184677.1517755496,360.78191385353529 | -179.145 | -8.62778e-08 | 0.159886 | -0.01249879493934461,-2.2149645371008585e-05,-0.013990238351214591 | 0.01249879398675024,1.0893525283543268,0.61779500368836004
