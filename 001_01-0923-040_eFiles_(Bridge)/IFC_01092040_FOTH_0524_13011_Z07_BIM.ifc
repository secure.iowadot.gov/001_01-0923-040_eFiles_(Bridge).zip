Properties of the parts of a building model (IFC4X3_ADD2), part 35 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.661Z | Line | 5333549.9571787901,2184689.8949924884,359.16629773731745 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.669Z | Line | 5333549.9543611826,2184690.0838845852,360.93644393149924 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.676Z | Line | 5333549.9543611826,2184690.0838845856,360.61601379941141 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.684Z | Line | 5333549.9543611826,2184690.0838845861,360.27804102691573 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.693Z | Line | 5333548.9160847971,2184690.1858851761,360.13366371246383 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.6891033782067666
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.703Z | Line String | 5333548.9160137791,2184690.1906462256,360.13486276323857 | 0 | 0 | 0 | 0,-0.012461839243769646,0 | 0.016062683425843716,0.00023677339777350426,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.712Z | Line | 5333548.9160137791,2184690.1906462256,360.13486276323857 | 0 | 0 | 0 | 0,-0.012698613107204437,0 | 0.00018941890448331833,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.723Z | Line | 5333548.9239504123,2184690.1907646125,360.13486276323857 | 0 | 0 | 0 | 0,0,0 | 0.088890289887785912,0.001325931865721941,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.731Z | Line | 5333549.0207773345,2184690.1922089309,360.13486276323857 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.741Z | Line | 5333549.004904069,2184690.1919721579,360.13486276323857 | 0 | 0 | 0 | 0,-0.012698613107204437,0 | 0.00018941890448331833,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.749Z | Line | 5333549.004975087,2184690.1872111079,360.13366371172015 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.7045374451603266
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.760Z | Line | 5333549.0128407022,2184690.1920905444,360.13486276323857 | 0 | 0 | 0 | 0,0,0 | 0.11428751423954964,0.0017047692090272903,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.768Z | Line | 5333549.1350648496,2184690.1939137005,360.13486276323857 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.776Z | Line | 5333549.1191915842,2184690.1936769271,360.13486276323857 | 0 | 0 | 0 | 0,-0.012698613107204437,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.785Z | Line | 5333549.1192626022,2184690.1889158776,360.13366371174209 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.794Z | Line | 5333549.1271282164,2184690.1937953136,360.13486276323857 | 0 | 0 | 0 | 0,0,0 | 0.11428751517087221,0.0017047692090272903,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.803Z | Line | 5333549.2493523648,2184690.1956184693,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.813Z | Line | 5333549.2334790984,2184690.1953816963,360.13486276323863 | 0 | 0 | 0 | 0,-0.012698613107204437,0 | 0.00018941890448331833,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.823Z | Line | 5333549.2335501164,2184690.1906206473,360.13366371174203 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.7442250443979788
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.831Z | Line | 5333549.2414157316,2184690.1955000828,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.12698612734675407,0.0018941881135106087,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.841Z | Line | 5333549.3588778991,2184690.1972522065,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.850Z | Line | 5333549.3398299804,2184690.1969680781,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.859Z | Line | 5333549.368401859,2184690.1973942709,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.15238335356116295,0.0022730259224772453,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.867Z | Line | 5333549.5112612536,2184690.1995252324,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.874Z | Line | 5333549.492213334,2184690.1992411041,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.882Z | Line | 5333549.6636446072,2184690.2017982579,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.892Z | Line | 5333549.6445966884,2184690.2015141295,360.13486276323863 | 0 | 0 | 0 | 0,-0.012698612175881863,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.900Z | Line | 5333549.5207852125,2184690.1996672968,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.15238335449248552,0.0022730259224772453,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.909Z | Line | 5333549.8160279617,2184690.2040712838,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.917Z | Line | 5333549.7969800429,2184690.2037871554,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.928Z | Line | 5333549.673168567,2184690.2019403228,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.15238335449248552,0.0022730259224772453,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.935Z | Line | 5333549.8255519215,2184690.2042133487,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502847909927,0.0034095384180545807,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.944Z | Line | 5333550.05412695,2184690.2076228871,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502941042185,0.003409538883715868,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.953Z | Line | 5333550.0446029911,2184690.2074808227,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.962Z | Line | 5333550.0255550714,2184690.2071966943,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.974Z | Line | 5333550.2827019794,2184690.211032426,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502847909927,0.003409538883715868,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.981Z | Line | 5333550.2731780196,2184690.2108903611,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.991Z | Line | 5333550.2541301008,2184690.2106062328,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.999Z | Line | 5333550.5112770079,2184690.2144419649,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502941042185,0.0034095384180545807,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.010Z | Line | 5333550.501753049,2184690.2142999,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.018Z | Line | 5333550.4827051293,2184690.2140157716,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.027Z | Line | 5333550.7398520373,2184690.2178515033,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502847909927,0.003409538883715868,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.036Z | Line | 5333550.7303280775,2184690.2177094389,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.045Z | Line | 5333550.7112801587,2184690.2174253105,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.056Z | Line | 5333550.9684270658,2184690.2212610422,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502941042185,0.0034095384180545807,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.064Z | Line | 5333550.9589031069,2184690.2211189773,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.074Z | Line | 5333550.9398551872,2184690.2208348489,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.083Z | Line | 5333551.1970020952,2184690.2246705806,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502847909927,0.003409538883715868,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.091Z | Line | 5333551.1874781353,2184690.2245285162,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.098Z | Line | 5333551.1684302166,2184690.2242443878,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.107Z | Line | 5333551.4255771236,2184690.2280801195,360.13486276323863 | 0 | 0 | 0 | 0,0,0 | 0.22857502941042185,0.003409538883715868,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.116Z | Line | 5333551.4160531638,2184690.2279380546,360.13486276323863 | 0 | 0 | 0 | 0,-0.012698612175881863,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.125Z | Line | 5333551.3970052451,2184690.2276539267,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.133Z | Line | 5333551.6255802745,2184690.2310634651,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.0001894170418381691,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.144Z | Line | 5333551.6446281932,2184690.2313475935,360.13486276323863 | 0 | 0 | 0 | 0,-0.01269861264154315,0 | 0.00018941797316074371,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.151Z | Complex Chain | 5333551.6545378342,2184690.2076811488,361.88346433824375 | 0 | 0 | 0 | -2.7623086608946323,-0.041205355897545815,-0.069515842109012738 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.161Z | Complex Chain | 5333551.6560058258,2184690.1092671664,361.88346433824375 | 0 | 0 | 0 | -2.7623086608946323,-0.041205356363207102,-0.069515842109012738 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.168Z | Line | 5333551.6545378342,2184690.2076811488,361.75646408424325 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693481177092,-2.2203039407031611e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.178Z | Line | 5333551.6545378342,2184690.2076811488,361.66121389374285 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693481177092,-2.2203039407031611e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.188Z | Line | 5333551.6545378342,2184690.2076811488,361.56596370324246 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693481177092,-2.2203039407031611e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.199Z | Line | 5333551.6545378342,2184690.2076811488,361.36276329684171 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693481177092,-2.2203039407031611e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.209Z | Line | 5333551.6545378342,2184690.2076811488,361.2357630428412 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693481177092,-2.2203039407031611e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.218Z | Line | 5333551.6545378342,2184690.2076811488,361.10876278884069 | 0 | 0 | 0 | -2.7682975577190518,-0.041294693481177092,-2.2203039407031611e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.228Z | Line | 5333548.9166819453,2184690.1458524126,360.1336637117202 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.6891033782067666
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.236Z | Line | 5333549.0058979029,2184690.1253456404,360.13366371171554 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.7045374451603266
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.246Z | Line | 5333549.1206041332,2184690.098979786,360.1336637117422 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.254Z | Line | 5333549.2350654816,2184690.0890307673,360.13366371174203 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,1.7442250443979788
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.264Z | Line | 5333551.709965243,2184689.8957985635,360.88715115726632 | 0 | 0 | 0 | -1.2148607298731804,0,-2.1032064978498966e-12 | 0,0.1028007403947413,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.274Z | Complex Chain | 5333551.6127892481,2184689.9198143966,360.39826643962886 | 0 | 0 | 0 | -0.0024362106024933038,0,0 | 1.862645149230957e-09,0.16331763318587289,0.95426667055769765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.290Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333548.834260189,2184689.8005161546,360.98246760799032 | 5333551.7107825289,2184690.2878327128,361.94696446543151
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.299Z | Complex Chain | 5333551.5944307419,2184690.0861806227,361.8917922194608 | 0 | 0 | 0 | 0,-0.15344360236859403,-0.85159357443305039 | 0.0022889215770497649,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.309Z | Line | 5333551.6568032838,2184690.0029638917,361.40772831848523 | 0 | 0 | 0 | -1.8982198908925056,0,-3.1832314562052488e-12 | 0,0.16062615718692541,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.317Z | Line | 5333551.657875929,2184689.9311214397,361.0432640822375 | 0 | 0 | 0 | -1.8982198899611831,0,-3.1263880373444408e-12 | 0,0.16062615718692541,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.332Z | Extended Element | 5333548.8342601908,2184690.2449950632,360.9824676083403 | 0.855167 | 4.5952e-09 | 90 | -2.1945198991346615e-09,-4.546363285840016e-14,-8.9138812997546779e-10 | 2.8702074740577226,0.96449685686095799,0.44452842000946469
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.357Z | Extended Element | 5333549.3399246763,2184690.1906197066,360.14102468649963 | 0.856183 | -0.0000566231 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.380Z | Extended Element | 5333549.4923080318,2184690.1928927321,360.14102468649969 | 0.856182 | -0.0000566234 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.404Z | Extended Element | 5333549.6446913853,2184690.195165758,360.14102468649975 | 0.856183 | -0.0000566666 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.431Z | Extended Element | 5333549.7970747408,2184690.1974387839,360.14102468649975 | 0.856182 | -0.0000566666 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.459Z | Extended Element | 5333550.0256497692,2184690.2008483224,360.14102468649969 | 0.856183 | -0.0000566231 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.483Z | Extended Element | 5333550.2542247986,2184690.2042578608,360.14102468649975 | 0.856182 | -0.000056624 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.509Z | Extended Element | 5333550.482799829,2184690.2076673997,360.14102468649963 | 0.856183 | -0.0000566663 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.534Z | Extended Element | 5333550.7113748575,2184690.211076939,360.14102468649963 | 0.856181 | -0.0000566669 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.561Z | Extended Element | 5333550.9399498887,2184690.2144864765,360.14102468649963 | 0.856184 | -0.0000565372 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.585Z | Extended Element | 5333551.1685249163,2184690.2178960154,360.14102468649969 | 0.856182 | -0.0000567105 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.612Z | Extended Element | 5333551.3970999476,2184690.2213055552,360.14102468649963 | 0.856183 | -0.0000566231 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.637Z | Extended Element | 5333551.6256749751,2184690.2247150936,360.14102468649969 | 0.856184 | -0.0000566231 | 89.9996 | -0.013708209169021768,-9.3219286280662248e-07,-0.013696475877447493 | 0.013704529919541047,1.3148923293457595,0.14706259781650832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.664Z | Extended Element | 5333548.916084799,2184690.1858851765,360.13366371246383 | -67.7254 | -2.70578e-09 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.688Z | Extended Element | 5333548.9166819472,2184690.1458524126,360.13366371172026 | -67.7254 | 9.55615e-09 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.716Z | Extended Element | 5333549.004975087,2184690.1872111084,360.13366371172015 | -67.7254 | -3.47378e-08 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.738Z | Extended Element | 5333549.0058979057,2184690.1253456413,360.13366371171554 | -67.7254 | -3.47378e-08 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.765Z | Extended Element | 5333549.1192626022,2184690.1889158781,360.13366371174214 | -67.7254 | -1.46615e-08 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.791Z | Extended Element | 5333549.1206041342,2184690.0989797865,360.13366371174226 | -67.7254 | -1.73119e-08 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.817Z | Extended Element | 5333549.2335501164,2184690.1906206473,360.13366371174209 | -67.7254 | -1.7115e-08 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.844Z | Extended Element | 5333549.2350654826,2184690.0890307683,360.13366371174209 | -67.7254 | -2.62026e-09 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.871Z | Extended Element | 5333551.612789249,2184689.9198143971,360.39826643962891 | -179.145 | 8.66816e-08 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.897Z | Extended Element | 5333551.5944307437,2184690.0861806232,361.89179221954487 | 0.85461 | 0.0000017677 | -101.012 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.919Z | Extended Element | 5333551.6545378342,2184690.2076811492,361.88346433824381 | -89.1454 | -3.1112e-07 | 180 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.945Z | Extended Element | 5333551.6560058258,2184690.1092671664,361.88346433824375 | -89.1454 | -3.1112e-07 | 180 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.972Z | Extended Element | 5333551.657875929,2184689.9311214397,361.0432640822375 | 85.1632 | 90.0079 | 7.005e-07 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:52.998Z | Extended Element | 5333551.6568032848,2184690.0029638922,361.40772831848511 | 85.1632 | 90.0079 | 6.8707e-07 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.022Z | Extended Element | 5333551.6545378342,2184690.2076811488,361.75646408424319 | 90.8546 | 90.0098 | 0.0000267323 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.048Z | Extended Element | 5333551.6545378352,2184690.2076811492,361.66121389374297 | 90.8546 | 90.0098 | 0.0000267464 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.076Z | Extended Element | 5333551.6545378352,2184690.2076811492,361.56596370324246 | 90.8546 | 90.0098 | 0.0000267464 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.100Z | Extended Element | 5333551.6545378342,2184690.2076811492,361.36276329684176 | 90.8546 | 90.0098 | 0.0000267685 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.126Z | Extended Element | 5333551.6545378352,2184690.2076811492,361.2357630428412 | 90.8546 | 90.0098 | 0.0000267709 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.153Z | Extended Element | 5333551.6545378352,2184690.2076811492,361.10876278884069 | 90.8546 | 90.0098 | 0.0000267873 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.180Z | Extended Element | 5333548.9339956203,2184690.0496121566,361.82552080720404 | 0.855139 | -2.085e-07 | -89.9982 | -0.013383672314236547,-2.5083639676360559e-07,-0.013393705419718058 | 0.013383672646049663,0.39914714553692082,0.14989860043402853
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.208Z | Extended Element | 5333549.0228859112,2184690.050938087,361.84095496503267 | 0.855138 | -2.78987e-08 | -89.9983 | -0.013383671999201482,-2.4193799773950873e-07,-0.013393736390429629 | 0.01338367305430911,0.4118471145939836,0.149898569833153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.235Z | Extended Element | 5333549.1371734235,2184690.0526428577,361.86079884937095 | 0.855138 | 1.95433e-08 | -89.9983 | -0.013383673838384916,-2.3365829091511947e-07,-0.013393766319802344 | 0.013383672722568426,0.42454708563157617,0.14989854031566802
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.259Z | Extended Element | 5333549.2514609313,2184690.054347625,361.88064484083026 | 0.855134 | -3.84307e-07 | -89.9985 | -0.013383665148291524,-2.0613436121344486e-07,-0.013392900089961343 | 0.013383665484346984,0.43724793801004758,0.14989939992524939
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.284Z | Extended Element | 5333549.3589725951,2184690.1909038341,361.88963748021041 | -179.145 | -6.40534e-08 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.321Z | Extended Element | 5333549.5113559496,2184690.1931768605,361.88963747986401 | -179.145 | 1.61442e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.347Z | Extended Element | 5333549.6637393031,2184690.1954498864,361.88963748011412 | -179.145 | 1.61435e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.372Z | Extended Element | 5333549.8161226576,2184690.1977229118,361.88963748061542 | -179.145 | -6.45472e-08 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.400Z | Extended Element | 5333550.044697688,2184690.2011324507,361.88963748037946 | -179.145 | 2.6017e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.428Z | Extended Element | 5333550.2732727174,2184690.2045419896,361.88963747980392 | -179.145 | 2.58527e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.453Z | Extended Element | 5333550.501847744,2184690.2079515276,361.88963748046433 | -179.145 | 2.09157e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.481Z | Extended Element | 5333550.7304227743,2184690.2113610655,361.88963747994194 | -179.145 | 2.10805e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.510Z | Extended Element | 5333550.9589978028,2184690.2147706053,361.88963748048235 | -179.145 | 2.09987e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.535Z | Extended Element | 5333551.1875728304,2184690.2181801433,361.88963748002334 | -179.145 | -6.50409e-08 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.562Z | Extended Element | 5333551.4161478598,2184690.2215896826,361.8896374798594 | -179.145 | 2.09987e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.589Z | Extended Element | 5333551.6467130501,2184690.0916640735,361.8896374799271 | 0.855134 | 1.36875e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.606Z | Line | 5333549.2929398427,2184690.1915067551,361.94037873262471 | 0 | 0 | 0 | -0.43901059497147799,-0.0065487218089401722,-0.076225596935444173 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.617Z | Complex Chain | 5333550.9260447593,2184689.977926278,360.39826643929149 | 0 | 0 | 0 | -0.0024362096711707292,0,0 | 1.862645149230957e-09,0.1633176327202116,0.95426667055775449
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.624Z | Complex Chain | 5333550.6971299322,2184689.9972969051,360.39826643934833 | 0 | 0 | 0 | -0.0024362096711707292,0,0 | 1.862645149230957e-09,0.1633176327202116,0.95426667055775449
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.635Z | Complex Chain | 5333550.4682150995,2184690.0166675318,360.39826644021582 | 0 | 0 | 0 | -0.0024362106024933038,0,0 | 1.862645149230957e-09,0.1633176327202116,0.95426667055775449
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.645Z | Line | 5333551.6469593504,2184690.0751520339,361.88963747991909 | 0 | 0 | 0 | -0.6857250826433301,-0.010228617116808891,0 | 0,0,6.1544369600596838e-10
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.671Z | Extended Element | 5333550.9260447593,2184689.977926278,360.39826643929155 | -179.145 | 1.73363e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.699Z | Extended Element | 5333550.6971299332,2184689.9972969051,360.39826643934839 | -179.145 | 1.72722e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.727Z | Extended Element | 5333550.4682150986,2184690.0166675323,360.39826644021582 | -179.145 | 1.7208e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.735Z | Line | 5333551.6440833248,2184690.267870089,361.93884959334542 | 0 | 0 | 0 | 0,-0.21907717036083341,0 | 0.0032679745927453041,0,0.0081148717917471913
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.750Z | Line | 5333551.7099652421,2184689.895798563,360.56672104971278 | 0 | 0 | 0 | -1.2148607298731804,0,-2.1032064978498966e-12 | 0,0.1028007403947413,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.761Z | Line | 5333551.1549595892,2184689.9585556509,360.98246760815351 | 0 | 0 | 0 | 0,-0.06825504032894969,-3.2855496101547033e-11 | 0.0010181264951825142,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.769Z | Line | 5333550.6971299313,2184689.9972969047,360.98246760775072 | 0 | 0 | 0 | 0,-0.068255040794610977,-3.2912339520407841e-11 | 0.0010181274265050888,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.779Z | Complex Chain | 5333551.3838744191,2184689.9391850214,360.39826643901853 | 0 | 0 | 0 | -0.0024362096711707292,0,0 | 1.862645149230957e-09,0.16331763318587289,0.95426667055775449
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.788Z | Complex Chain | 5333551.1549595892,2184689.9585556509,360.39826643975107 | 0 | 0 | 0 | -0.0024362106024933038,0,0 | 1.862645149230957e-09,0.1633176327202116,0.95426667055775449
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.815Z | Extended Element | 5333551.3838744191,2184689.9391850214,360.39826643901858 | -179.145 | 8.66816e-08 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.842Z | Extended Element | 5333551.1549595892,2184689.9585556514,360.39826643975113 | -179.145 | 2.58761e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.851Z | Complex Chain | 5333551.3655159138,2184690.1055512475,361.89179221885041 | 0 | 0 | 0 | 0,-0.15344360283425532,-0.85159357443305039 | 0.0022889215770497649,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.862Z | Complex Chain | 5333551.1366010839,2184690.1249218741,361.89179221915293 | 0 | 0 | 0 | 0,-0.15344360283425532,-0.85159357443310724 | 0.0022889215770497649,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.888Z | Extended Element | 5333551.1366010839,2184690.1249218741,361.89179221915811 | 0.854608 | 0.00000219723 | -101.012 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.916Z | Extended Element | 5333551.3655159129,2184690.1055512475,361.89179221878322 | 0.854609 | 0.00000201148 | -101.012 | -0.011443491256555196,-3.9333348243001345e-06,-0.011046557150140175 | 0.011443489494025183,0.86705629459861755,0.12295323288063038
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.927Z | Complex Chain | 5333548.893774366,2184690.1934910514,361.7564640839874 | 0 | 0 | 0 | 0,-0.12457627376150229,0 | 2.7622314598411322,0,2.5587292697813685e-10
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.954Z | Extended Element | 5333551.6560058258,2184690.1092671659,361.75646408424325 | 90.8546 | -90 | 1.81516e-16 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.967Z | Complex Chain | 5333548.893774366,2184690.1934910519,361.661213893487 | 0 | 0 | 0 | 0,-0.12457627376150229,0 | 2.7622314598411322,0,2.5587292697813685e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:53.976Z | Complex Chain | 5333548.893774366,2184690.1934910524,361.56596370298661 | 0 | 0 | 0 | 0,-0.12457627376150229,0 | 2.7622314598411322,0,2.5587292697813685e-10
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.001Z | Extended Element | 5333551.6560058268,2184690.1092671668,361.66121389374291 | 90.8546 | -90 | 0 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.027Z | Extended Element | 5333551.6560058268,2184690.1092671673,361.56596370324246 | 90.8546 | -90 | -1.81475e-16 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.035Z | Complex Chain | 5333551.6547242636,2184690.1092480514,361.36276329684171 | 0 | 0 | 0 | -2.766117375344038,-0.037197120022028685,0 | 0,0.025421769823879004,5.6843418860808015e-14
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.047Z | Complex Chain | 5333551.6547242636,2184690.1092480519,361.2357630428412 | 0 | 0 | 0 | -2.766117375344038,-0.037197120022028685,0 | 0,0.025421769823879004,5.6843418860808015e-14
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.055Z | Complex Chain | 5333551.654729371,2184690.1092481283,361.10876278884069 | 0 | 0 | 0 | -2.7661173744127154,-0.037197120487689972,0 | 0,0.025421769823879004,5.6843418860808015e-14
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.067Z | Complex Chain | 5333550.9189365609,2184690.0982726705,360.92056889974918 | 0 | 0 | 0 | -2.0303245643153787,-0.026221668813377619,0 | 0,0.036397221498191357,5.6843418860808015e-14
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.076Z | Complex Chain | 5333550.9189365609,2184690.098272671,360.60013876766141 | 0 | 0 | 0 | -2.0303245643153787,-0.026221668813377619,0 | 0,0.036397221498191357,5.6843418860808015e-14
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.102Z | Extended Element | 5333551.6547242645,2184690.1092480519,361.36276329684176 | 90.8546 | -90 | 0 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.129Z | Extended Element | 5333551.6547242636,2184690.1092480514,361.2357630428412 | 89.4734 | -90 | -1.38115 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.155Z | Extended Element | 5333551.654729371,2184690.1092481287,361.10876278884075 | 90.8546 | -90 | 0 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.165Z | Line | 5333549.1623208737,2184690.0720688691,361.86058974526287 | 0 | 0 | 0 | -0.0012815622612833977,-1.911679282784462e-05,-5.6843418860808015e-14 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.176Z | Line | 5333549.1610393114,2184690.0720497523,361.86058974526281 | 0 | 0 | 0 | 0,-0.00041378848254680634,0 | 6.1728060245513916e-06,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.184Z | Line String | 5333551.6468496714,2184690.0901074023,360.95078224819628 | 0 | 0 | 0 | -2.7128558522090316,-0.040466306731104851,-1.1368683772161603e-13 | 0,0,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.194Z | Line | 5333551.1864114702,2184690.0832392774,360.95078224819628 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,0.053780962995460868
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.202Z | Line | 5333550.7292614095,2184690.0764201996,360.95078224819633 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,0.036303225580581966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.213Z | Line | 5333550.0625836654,2184690.0664757034,360.95078224819628 | 0 | 0 | 0 | 0,0,0 | 0,0,0.037554252551672107
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.221Z | Line | 5333549.357811288,2184690.0559629677,360.95078224819622 | 0 | 0 | 0 | 0,0,0 | 0,0,0.037554252551672107
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.232Z | Line | 5333548.9339938192,2184690.0496410956,360.95078224819616 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,0.073869316551167685
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.243Z | Complex Chain | 5333551.183710522,2184690.2641950781,360.85553221131687 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163072108762,-0.05526269414684748 | 0.005401897974516779,4.6566128730773926e-10,0.095250076324538441
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.251Z | Complex Chain | 5333551.1891112719,2184689.9022834287,360.53510210438316 | 0 | 0 | 0 | -0.0054018999915360719,0,-0.055262695563897068 | 9.3132257461547852e-10,0.36191163211576716,0.09525007482546391
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.263Z | Complex Chain | 5333550.7265604613,2184690.2573760008,360.85553221131687 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163072108762,-0.05526269414684748 | 0.005401897974516779,4.6566128730773926e-10,0.095250076324538441
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.272Z | Complex Chain | 5333550.7319612112,2184689.8954643509,360.53510210438316 | 0 | 0 | 0 | -0.0054018999915360728,0,-0.055262695563897068 | 9.3132257461547852e-10,0.36191163258142844,0.09525007482546391
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.282Z | Complex Chain | 5333550.0598827172,2184690.2474315045,360.85553221131687 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163072108762,-0.05526269414684748 | 0.0054018970431942044,4.6566128730773926e-10,0.095250076324538441
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.291Z | Complex Chain | 5333550.0652834661,2184689.8855198547,360.53510210438316 | 0 | 0 | 0 | -0.0054018990602134982,0,-0.055262695563897068 | 1.3401838582036835e-09,0.36191163258142844,0.09525007482546391
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.299Z | Complex Chain | 5333548.9312928719,2184690.2305968977,360.85553221131687 | 0 | 0 | 0 | -1.1858093363573824e-09,-0.36191163025542633,-0.05526269414684748 | 0.0054018970431942044,5.681849366001579e-10,0.095250076324538441
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.308Z | Complex Chain | 5333548.9366936209,2184689.8686852483,360.53510210438316 | 0 | 0 | 0 | -0.0054018990602134982,0,-0.055262695563897068 | 9.3132257461547852e-10,0.36191163258142844,0.09525007482546391
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.317Z | Complex Chain | 5333549.3551103398,2184690.2369187698,360.85553221131687 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163072108762,-0.05526269414684748 | 0.005401897974516779,4.6566128730773926e-10,0.095250076324538441
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.328Z | Complex Chain | 5333549.3605110897,2184689.8750071204,360.53510210438316 | 0 | 0 | 0 | -0.0054018999915360728,0,-0.055262695563897068 | 9.3132257461547852e-10,0.36191163211576716,0.09525007482546391
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.337Z | Line | 5333551.6569257583,2184689.9947534516,361.36541897115393 | 0 | 0 | 0 | -1.8982198908925056,0,-3.1832314562052488e-12 | 0,0.16062615672126412,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.348Z | Line | 5333551.657875929,2184689.9311214397,361.0432640822375 | 0 | 0 | 0 | -1.8982198899611831,0,-3.1263880373444408e-12 | 0,0.16062615718692541,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.368Z | Complex Chain | 5333605.7207340328,2184676.8536435547,361.94178373705807 | 0 | 0 | 0 | -0.0019901590421795845,-1.2632020429670376e-10,-0.85407499989556968 | 4.6566128730773926e-09,0.13333514844998717,2.0264678823878057e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.379Z | Complex Chain | 5333605.9493090622,2184676.8570530931,361.94178373789788 | 0 | 0 | 0 | -0.0019901609048247337,-5.9198149160444302e-10,-0.85407499990415303 | 3.7252902984619141e-09,0.13333514844998717,1.8820855984813534e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.387Z | Complex Chain | 5333606.1778840916,2184676.8604626325,361.94178373897665 | 0 | 0 | 0 | -0.001990162767469883,-1.0576452769139877e-09,-0.85407499984810542 | 2.8556307615865834e-09,0.13333514798432589,2.971773938043043e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.399Z | Complex Chain | 5333606.4064591192,2184676.8638721714,361.94178374035027 | 0 | 0 | 0 | -0.0019901599735021591,-5.9198149160444302e-10,-0.85407499990045821 | 4.6566128730773926e-09,0.13333514798432589,1.9542767404345796e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.409Z | Complex Chain | 5333606.6350341486,2184676.8672817098,361.94178374072487 | 0 | 0 | 0 | -0.001990162767469883,-1.2631992674094761e-10,-0.85407499989937818 | 3.7871379884087814e-09,0.13333514891564846,1.9542767404345796e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.418Z | Complex Chain | 5333606.8636091789,2184676.8706912491,361.94178374216187 | 0 | 0 | 0 | -0.0019901618361473083,-1.2631992674094761e-10,-0.85407499988306412 | 3.7871379630384505e-09,0.13333514891564846,2.2453150450019166e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.428Z | Complex Chain | 5333607.0921842074,2184676.8741007871,361.94178374241642 | 0 | 0 | 0 | -0.0019901590421795845,-1.2632020429670376e-10,-0.85407499990887104 | 4.6566128730773926e-09,0.13333514844998717,1.8815171642927453e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.436Z | Complex Chain | 5333607.3207592359,2184676.8775103255,361.94178374390668 | 0 | 0 | 0 | -0.001990162767469883,-1.2631992674094761e-10,-0.85407499990102664 | 3.7871379884087814e-09,0.13333514844998717,2.0997958927182481e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.446Z | Complex Chain | 5333607.5493342644,2184676.8809198644,361.94178374505731 | 0 | 0 | 0 | -0.0019901618361473083,-5.9198121404868687e-10,-0.8540749999035846 | 3.7252902984619141e-09,0.13333514844998717,1.9542767404345796e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.455Z | Complex Chain | 5333607.7017176189,2184676.8831928903,361.94178374516582 | 0 | 0 | 0 | -0.0019901636987924576,-1.5233036082529239e-09,-0.85407499989551283 | 3.7871510500091937e-09,0.13333514844998717,2.1003643269068561e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.466Z | Complex Chain | 5333607.8541009724,2184676.8854659158,361.9417837455257 | 0 | 0 | 0 | -0.0019901590421795845,-5.9198149160444302e-10,-0.85407499989750235 | 4.7184474652114949e-09,0.13333514891564846,1.9548451746231876e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.476Z | Complex Chain | 5333608.0064843278,2184676.8877389422,361.94178374648192 | 0 | 0 | 0 | -0.001990162767469883,-1.2631992674094761e-10,-0.85407499990023084 | 2.8558154137933028e-09,0.13333514891564846,1.9537083062459715e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.485Z | Complex Chain | 5333608.4334988603,2184676.8925208258,361.87766944127031 | 0 | 0 | 0 | -0.0020375577732920647,0,-0.38576368320487503 | 2.374611665720977e-09,0.13650979520753026,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.495Z | Complex Chain | 5333608.3446085695,2184676.8911948949,361.89310350800002 | 0 | 0 | 0 | -0.0020375587046146393,0,-0.39846363792789341 | 9.3132257461547852e-10,0.13650979520753026,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.504Z | Complex Chain | 5333608.2303210553,2184676.8894901248,361.91294730746728 | 0 | 0 | 0 | -0.0020375568419694901,0,-0.41116359551923065 | 1.862645149230957e-09,0.13650979586640055,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.514Z | Complex Chain | 5333608.1160335392,2184676.887785356,361.93279110752303 | 0 | 0 | 0 | -0.0020375475287437439,0,-0.42386249988972607 | 3.3451542339087148e-09,0.13650979474186897,2.2947688194108196e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.523Z | Complex Chain | 5333605.7213082025,2184676.8075795751,360.90767846836764 | 0 | 0 | 0 | -0.0054018979745163375,-5.6818491578347619e-10,-0.055262693693748588 | 2.544864469980132e-10,0.36191163025542633,0.095250076809412818
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.533Z | Complex Chain | 5333605.7159074545,2184677.1694912249,360.58724836200383 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163258142844,-0.055262696017052804 | 0.005401899991536418,0,0.095250074340475846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.545Z | Complex Chain | 5333605.7397819543,2184676.8539276859,360.19317094369961 | 0 | 0 | 0 | -0.0019901707971169925,0,0 | 0,0.13333515111410527,1.3012192101712545
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.553Z | Complex Chain | 5333605.9683569837,2184676.8573372248,360.19317094461439 | 0 | 0 | 0 | -0.0019901717284395671,0,0 | 0,0.13333515064844398,1.3012192101532352
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.563Z | Complex Chain | 5333606.1969320122,2184676.8607467632,360.19317094552923 | 0 | 0 | 0 | -0.0019901726594088926,-8.0147810610498027e-10,0 | 0,0.13333514938130975,1.3012192102329296
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.572Z | Complex Chain | 5333606.4255070416,2184676.8641563021,360.19317094644401 | 0 | 0 | 0 | -0.0019901698657944253,0,0 | 0,0.13333515064844398,1.3012192101650586
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.580Z | Complex Chain | 5333606.654082072,2184676.8675658405,360.19317094735874 | 0 | 0 | 0 | -0.001990171728086292,-3.358167910416654e-10,0 | 0,0.13333515077829361,1.3012192102377613
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.588Z | Complex Chain | 5333606.8826571004,2184676.8709753794,360.19317094827352 | 0 | 0 | 0 | -0.0019901717284395741,0,0 | 0,0.13333515111410527,1.3012192101621027
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.596Z | Complex Chain | 5333607.1112321317,2184676.8743849183,360.1931709491883 | 0 | 0 | 0 | -0.0019901707971169986,0,0 | 0,0.13333514971712135,1.3012192101588058
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.604Z | Complex Chain | 5333607.3398071611,2184676.8777944567,360.19317095010314 | 0 | 0 | 0 | -0.0019901717284395732,0,0 | 0,0.1333351506484439,1.3012192101594311
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.615Z | Complex Chain | 5333607.5683821896,2184676.8812039956,360.19317095101786 | 0 | 0 | 0 | -0.0019901717284395732,0,0 | 0,0.13333515018278261,1.3012192101633533
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.623Z | Complex Chain | 5333607.7207655441,2184676.8834770215,360.19317095162774 | 0 | 0 | 0 | -0.0019901717284395728,0,0 | 0,0.13333514984697104,1.3012192101625006
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.634Z | Complex Chain | 5333607.8731488995,2184676.8857500469,360.19317095223755 | 0 | 0 | 0 | -0.0019901707971169981,0,0 | 0,0.13333515111410515,1.3012192101688103
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.643Z | Complex Chain | 5333608.025532254,2184676.8880230729,360.19317095284742 | 0 | 0 | 0 | -0.0019901707971169977,0,0 | 0,0.13333515111410515,1.3012192101714819
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.652Z | Line | 5333608.4542288044,2184676.8864802583,360.9805725293964 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.662Z | Line | 5333608.1712311488,2184676.8822589251,360.98057252826379 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.670Z | Line | 5333607.6052358365,2184676.8738162583,360.98057252599864 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.680Z | Line | 5333607.3222381808,2184676.8695949246,360.98057252486609 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.688Z | Line | 5333607.0392405251,2184676.865373591,360.98057252373349 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.699Z | Line | 5333606.7562428694,2184676.8611522573,360.98057252260088 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.714Z | Line | 5333606.4732452128,2184676.8569309241,360.98057252146828 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.722Z | Line | 5333608.4493039278,2184677.216643224,360.98057252968113 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.730Z | Line | 5333608.1663062721,2184677.2124218908,360.98057252854852 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.739Z | Line | 5333607.8833086155,2184677.2082005576,360.98057252741597 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.747Z | Line | 5333607.6003109599,2184677.203979224,360.98057252628337 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.755Z | Line | 5333607.3173133042,2184677.1997578903,360.98057252515082 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.764Z | Line | 5333607.0343156485,2184677.1955365567,360.98057252401816 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.773Z | Line | 5333606.7513179928,2184677.191315223,360.98057252288561 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.781Z | Line | 5333606.4683203362,2184677.1870938898,360.980572521753 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.788Z | Line | 5333608.4798864797,2184676.869398504,360.95517247851461 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.797Z | Line | 5333608.4798864815,2184676.869398505,360.63474237091998 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.806Z | Line | 5333608.4798864825,2184676.8693985059,360.31431226332541 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.816Z | Line | 5333608.4798864843,2184676.8693985073,359.99388215573077 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.826Z | Line | 5333608.4798391294,2184676.8725731606,359.79068174933496 | 0 | 0 | 0 | -2.0317780403420329,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.835Z | Line | 5333608.4798864853,2184676.8693985082,359.68908154612956 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.846Z | Line | 5333608.4798864871,2184676.8693985068,359.20256897340136 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.855Z | Line | 5333608.4798864862,2184676.8693985092,359.44582525974909 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.864Z | Line | 5333608.4749616124,2184677.199561473,359.2025689739213 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.872Z | Line | 5333608.4749616114,2184677.1995614753,359.44582526026898 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.882Z | Line | 5333608.4749616105,2184677.1995614744,359.6890815466495 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.890Z | Line | 5333608.4749616096,2184677.1995614734,359.99388215625072 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.900Z | Line | 5333608.4749616077,2184677.1995614721,360.3143122638453 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.909Z | Line | 5333608.4749616068,2184677.1995614711,360.63474237143993 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.918Z | Line | 5333608.4749616049,2184677.1995614702,360.95517247903456 | 0 | 0 | 0 | -2.0317780412733555,-0.030307012144476175,-7.9419351095566526e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.929Z | Line | 5333607.4132030103,2184676.853487323,360.97104750618496 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.939Z | Line | 5333607.4132030122,2184676.8534873235,360.65061739843378 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.948Z | Line | 5333607.4132030131,2184676.853487324,360.33018729107158 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
