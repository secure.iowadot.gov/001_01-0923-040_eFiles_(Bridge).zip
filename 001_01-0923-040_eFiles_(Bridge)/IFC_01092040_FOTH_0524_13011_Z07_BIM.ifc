Properties of the parts of a building model (IFC4X3_ADD2), part 20 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.882Z | Line String | 5333590.340943112,2184683.5702664284,361.04197286864945 | 0 | 0 | 0 | 0,0,-0.0092726266608451624 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.893Z | Line String | 5333590.4429348959,2184683.8640478821,361.04192379237651 | 0 | 0 | 0 | 0,0,-0.009387127954994412 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.902Z | Line String | 5333590.5449266816,2184684.1578293359,361.0396773776892 | 0 | 0 | 0 | 0,0,-0.009501629249200505 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.913Z | Line String | 5333590.6469184654,2184684.4516107896,361.03563857313452 | 0 | 0 | 0 | 0,0,-0.0096270673091112258 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.923Z | Line String | 5333590.7472037384,2184684.740476734,361.03019703627297 | 0 | 0 | 0 | 0,0,-0.009739652783650854 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.932Z | Line String | 5333590.7826637235,2184684.8426171779,361.02809847309129 | 0 | 0 | 0 | 0,0,-0.0097794620130571275 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.942Z | Line String | 5333590.8535836954,2184685.046898067,361.02390217190776 | 0 | 0 | 0 | 0,0,-0.0098590804679474786 | 7.6699587143957615,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.950Z | Line String | 5333590.8890436813,2184685.1490385109,361.02189615118516 | 0 | 0 | 0 | 0,0,-0.009898889696387414 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.961Z | Line String | 5333590.9915452031,2184685.4442882333,361.0159051057467 | 0 | 0 | 0 | 0,0,-0.010013963248127311 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.968Z | Line String | 5333591.093536987,2184685.738069687,361.0099434701466 | 0 | 0 | 0 | 0,0,-0.010128464542447091 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.979Z | Line String | 5333591.1955287717,2184686.0318511403,361.00415577979913 | 0 | 0 | 0 | 0,0,-0.010242965836937401 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.989Z | Line String | 5333591.2975205565,2184686.3256325936,360.99811074948354 | 0 | 0 | 0 | 0,0,-0.010357467131314024 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.997Z | Line String | 5333591.3995123403,2184686.6194140473,360.99219421138599 | 0 | 0 | 0 | 0,0,-0.010471968425690648 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.008Z | Line String | 5333591.5015041251,2184686.9131955011,360.98618062533666 | 0 | 0 | 0 | 0,0,-0.010586469719100933 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.016Z | Line String | 5333591.6017893972,2184687.2020614455,360.98048650561856 | 0 | 0 | 0 | 0,0,-0.010699055193583717 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.026Z | Line String | 5333591.6372493831,2184687.3042018893,360.97831505263593 | 0 | 0 | 0 | 0,0,-0.010738864423046834 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.034Z | Line String | 5333591.7081693551,2184687.5084827784,360.97416130005746 | 0 | 0 | 0 | 0,0,-0.010818482877994029 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.046Z | Line String | 5333591.743629341,2184687.6106232223,360.97219527949107 | 0 | 0 | 0 | 0,0,-0.010858292106433964 | 7.6699587125331163,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.054Z | Line String | 5333591.8461308628,2184687.9058729447,360.96620824082731 | 0 | 0 | 0 | 0,0,-0.010973365658117018 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.065Z | Line String | 5333591.9481226467,2184688.1996543985,360.96027915769656 | 0 | 0 | 0 | 0,0,-0.011087866952493641 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.074Z | Line String | 5333592.0501144305,2184688.4934358522,360.95434042747553 | 0 | 0 | 0 | 0,0,-0.011202368246927108 | 7.6699587143957615,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.083Z | Line String | 5333592.1521062162,2184688.7872173055,360.94841417480524 | 0 | 0 | 0 | 0,0,-0.011327806307974697 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.094Z | Line String | 5333592.254098,2184689.0809987588,360.94238375676184 | 0 | 0 | 0 | 0,0,-0.011442307602237634 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.101Z | Line String | 5333592.3560897838,2184689.3747802125,360.93656831787393 | 0 | 0 | 0 | 0,0,-0.011556808895420545 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.112Z | Line String | 5333592.4563750569,2184689.6636461569,360.93062198696811 | 0 | 0 | 0 | 0,0,-0.0116693943697328 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.120Z | Line String | 5333592.4918350428,2184689.7657866012,360.92859933559652 | 0 | 0 | 0 | 0,0,-0.01170920359908223 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.131Z | Line String | 5333592.5627550147,2184689.9700674904,360.924356388597 | 0 | 0 | 0 | 0,0,-0.011788822056075787 | 7.6699587134644389,0.11440891912207007,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.157Z | Extended Element | 5333569.14652343,2184689.6207793346,360.90893905237857 | -89.1454 | 0.00000117874 | -179.862 | -0.012700000154758254,-1.0976418175821012e-10,-0.012700000001127532 | 0.012700003902004367,7.6708561541785549,0.016119795190665101
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.182Z | Extended Element | 5333569.0756034572,2184689.4164984464,360.91292722031397 | -89.1454 | -0.000170933 | -179.862 | -0.012700000089519497,9.2313157100497658e-11,-0.01270000000034106 | 0.012700007539875047,7.6708563470207229,0.016199413410275348
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.211Z | Extended Element | 5333569.040143474,2184689.314358002,360.91482248215289 | -89.1454 | -0.000125759 | -179.862 | -0.01270000019627001,-1.1298341650987712e-10,-0.012700000001926786 | 0.012700005282802468,7.670856443138609,0.016239222532181893
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.237Z | Extended Element | 5333568.9398581991,2184689.0254920567,360.9204085395366 | -89.1454 | -0.0000308141 | -179.862 | -0.012700000556281409,3.271728105657576e-11,-0.012700000005091699 | 0.012700002315998922,7.6708567141304709,0.016351807680303705
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.264Z | Extended Element | 5333568.8378664162,2184688.7317106039,360.92585757428913 | -89.1454 | -0.000106317 | -179.862 | -0.01270000031144994,5.1185515158498087e-10,-0.012700000005159395 | 0.012700004946129856,7.6708569902220916,0.016466308645227464
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.293Z | Extended Element | 5333568.7358746314,2184688.4379291506,360.93152158819129 | -89.1454 | -0.0000729184 | -179.862 | -0.012700000196092218,-3.7099186987282122e-10,-0.012699999998408392 | 0.012700004563912135,7.6708572658995093,0.016580809618303882
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.319Z | Extended Element | 5333568.6338828467,2184688.1441476964,360.93709300588978 | -89.1454 | -0.000185883 | -179.862 | -0.012700000209778076,3.2466555199037823e-10,-0.012700000002639851 | 0.012700008617752476,7.6708575431639803,0.016695310547523858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.347Z | Extended Element | 5333568.5318910638,2184687.8503662432,360.94268823222916 | -89.1454 | 0.00000619821 | -179.862 | -0.012700000403830661,2.999423408878423e-10,-0.012700000002794495 | 0.012700000319141067,7.6708578187515393,0.016809811527208552
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.378Z | Extended Element | 5333560.7599405656,2184687.4421758717,360.92555971988912 | -89.1454 | 180 | -0.199785 | -0.012700005213834957,7.6131545475266114e-11,-0.012700000001421092 | 0.012699999792955228,7.6708581980863464,0.016733441559336606
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.401Z | Extended Element | 5333560.6574390437,2184687.1469261483,360.93108646434797 | -89.1454 | 180 | -0.199785 | -0.012700003458535463,-4.6499204490801842e-10,-0.012700000000511599 | 0.012700000117743237,7.6708585980884703,0.016618368717558715
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.427Z | Extended Element | 5333560.6219790559,2184687.0447857045,360.93289324799997 | -89.1454 | -180 | -0.199785 | -0.012700000044634939,-9.4004857187186298e-11,-0.012700000003834323 | 0.012700005449333369,7.6708587386555163,0.016578559700286977
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.454Z | Extended Element | 5333560.5510590887,2184686.8405048158,360.93672852676804 | -89.1454 | 180 | -0.199785 | -0.01270000437008262,-1.2779296407961275e-11,-0.012700000006047733 | 0.01270000043714065,7.6708590124409977,0.016498941764831413
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.482Z | Extended Element | 5333560.5155990999,2184686.7383643719,360.93874074283121 | -89.1454 | 180 | -0.199785 | -0.012700012035501956,-5.3373538869343937e-10,-0.012700000003245967 | 0.012700000368411754,7.6708591530608476,0.016459132736092414
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.510Z | Extended Element | 5333560.4153138278,2184686.4494984271,360.94398452064763 | -89.1454 | 180 | -0.199785 | -0.012700005531615778,-9.9833593685724927e-11,-0.012700000002848773 | 0.01270000069227782,7.6708595454545838,0.016346547966310646
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.544Z | Extended Element | 5333560.3133220421,2184686.1557169743,360.94954010153208 | -89.1454 | 180 | -0.199785 | -0.012700001878176964,-1.521577931124306e-10,-0.012700000002825033 | 0.012700000034312455,7.6708599440379768,0.016232047353925218
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.571Z | Extended Element | 5333560.2113302602,2184685.8619355205,360.95499863444547 | -89.1454 | 180 | -0.199785 | -0.012700002972817263,2.2781191057690754e-10,-0.012700000001920326 | 0.012700000369787206,7.6708603440073801,0.016117546776005496
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.599Z | Extended Element | 5333560.1093384754,2184685.5681540668,360.96057908780847 | -89.1454 | 180 | -0.200028 | -0.012700002243919485,4.1201023357518886e-11,-0.012700000001834105 | 0.012700000144672468,7.670858107229197,0.016028905230428742
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.625Z | Extended Element | 5333567.6773054032,2184685.3887815317,360.98945580217844 | -89.1454 | 0.000096882 | -179.85 | -0.012700004388215353,-6.5476588371325653e-10,-0.012700000001764704 | 0.012700000155342008,7.6708610717140466,0.016128589698945522
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.651Z | Extended Element | 5333567.5753136184,2184685.095000078,360.99505103363526 | -89.1454 | 0.00013694 | -179.85 | -0.012700006982070432,-6.4167294485423755e-10,-0.01270000000210344 | 0.012699999936028796,7.6708613730883766,0.016243090610849529
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.679Z | Extended Element | 5333567.4728120966,2184684.799750356,361.00067384371283 | -89.1454 | 0.0000564575 | -179.85 | -0.012700002848799416,8.6508922476272285e-10,-0.012699999999829473 | 0.012700000260446813,7.6708616759539856,0.016358163753011468
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.704Z | Extended Element | 5333567.4373521097,2184684.6976099126,361.00255247489991 | -89.1454 | -0.000182087 | -179.85 | -0.012700000000745401,-1.0462164470821317e-10,-0.012700000000625275 | 0.012700008343904879,7.6708617779810897,0.016397972848820185
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.732Z | Extended Element | 5333567.3664321396,2184684.4933290235,361.00649399703161 | -89.1454 | 0.0000162605 | -179.85 | -0.012700001316943205,-4.1207892664663071e-10,-0.012699999999545264 | 0.012700000351986849,7.6708619884357612,0.016477591026345481
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.759Z | Extended Element | 5333567.3309721556,2184684.3911885782,361.00846517067896 | -89.1454 | 0.000275892 | -179.85 | -0.012700014341363874,6.4644062039431531e-10,-0.012700000003554769 | 0.012700000430042917,7.6708620943984158,0.016517400102176932
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.786Z | Extended Element | 5333567.2306868834,2184684.1023226338,361.01354643402266 | -89.1454 | 0.00000141235 | -179.85 | -0.012700000438300973,-5.9182448063884723e-10,-0.012700000002205128 | 0.012700000759457862,7.6708623907096261,0.016629985231521427
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.814Z | Extended Element | 5333567.1286950968,2184683.8085411806,361.01724023918041 | -89.1454 | 0.000129957 | -179.85 | -0.012700006398789355,1.2307332925726128e-10,-0.012700000000000003 | 0.012700000276930887,7.6708626899214511,0.016744486107738724
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.841Z | Extended Element | 5333559.3567445995,2184683.4003508096,360.99484282070449 | -89.1454 | -180 | -0.212121 | -0.012700000441409086,-2.5750852727419172e-10,-0.012700000004168288 | 0.012700002666658041,7.6708630233304991,0.016798761411351365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.868Z | Extended Element | 5333559.2547528157,2184683.1065693549,360.99443389180772 | -89.1454 | -180 | -0.212121 | -0.01269999984279698,-1.7057475185068347e-10,-0.012700000005729286 | 0.012700005396068725,7.670863445894879,0.016684260934748528
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.895Z | Extended Element | 5333559.1527610291,2184682.8127879016,360.99186603487703 | -89.1454 | -180 | -0.212121 | -0.012700000360895625,6.13868767836105e-10,-0.012700000003911503 | 0.012700006560030947,7.6708638729713625,0.016569760424448878
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.922Z | Extended Element | 5333559.0507692443,2184682.5190064479,360.9875878873425 | -89.1454 | 180 | -0.212121 | -0.012700001736805184,2.248514127071295e-10,-0.01270000000767796 | 0.012700000160534802,7.6708642969646199,0.016455259884728103
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.948Z | Extended Element | 5333558.9482677244,2184682.2237567264,360.98160712230225 | -89.1454 | -180 | -0.212121 | -0.012699999932978405,2.1998485601421971e-10,-0.012700000004634783 | 0.012700003427901436,7.6708647203910187,0.016340187127040287
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.976Z | Extended Element | 5333558.9128077403,2184682.1216162816,360.97943821179848 | -89.1454 | -180 | -0.212121 | -0.012700000196536904,1.194565769546127e-10,-0.012700000005639183 | 0.01270000531485423,7.6708648690660084,0.016300378175730049
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:52.998Z | Extended Element | 5333558.8418877665,2184681.9173353929,360.97510039058557 | -89.1454 | -180 | -0.212121 | -0.012700000043645661,3.8233504256709007e-10,-0.012700000002409629 | 0.012700005896727784,7.6708651649680073,0.016220760272338122
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.023Z | Extended Element | 5333558.8064277824,2184681.815194949,360.97293148006906 | -89.1454 | -180 | -0.212121 | -0.012700000197186371,-4.9694683458419036e-10,-0.012700000001383696 | 0.012700003621475725,7.670865310000675,0.016180951333102496
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.049Z | Extended Element | 5333558.7061425084,2184681.5263290037,360.9667975301366 | -89.1454 | -180 | -0.212121 | -0.01270000040804316,-3.2421557564677172e-10,-0.012700000003933216 | 0.012700006525081938,7.670865725975534,0.016068366631302289
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.078Z | Extended Element | 5333566.274109439,2184681.3469564691,360.98569896073542 | -89.1454 | -0.000137561 | -179.837 | -0.012700000725696482,-5.4420235106705934e-10,-0.012700000001281535 | 0.012700005716181203,7.6708661415372763,0.016063264530386798
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.104Z | Extended Element | 5333566.1721176542,2184681.0531750154,360.9795522325465 | -89.1454 | -0.00011788 | -179.837 | -0.012700000079332889,5.125468937339196e-10,-0.012699999999715788 | 0.012700005165875841,7.670866465888114,0.01617776535972363
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.130Z | Extended Element | 5333566.0701258695,2184680.7593935621,360.97340550450713 | -89.1454 | -0.0000924691 | -179.837 | -0.012700000029782124,1.281688733183708e-10,-0.012699999999715791 | 0.012700004731966349,7.6708667916604583,0.016292266193398849
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.156Z | Extended Element | 5333565.9681340829,2184680.4656121084,360.96746672262776 | -89.1454 | -0.0000710886 | -179.837 | -0.012699999977436359,-2.9471650621359554e-10,-0.012700000000804956 | 0.012700004318834284,7.6708671135819673,0.016406767014355381
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.180Z | Extended Element | 5333565.8661423,2184680.1718306555,360.96111204823137 | -89.1454 | -0.0000679458 | -179.837 | -0.01270000030420361,4.7444189292915771e-10,-0.012700000002935212 | 0.012700001841405842,7.670867441461759,0.01652126786317298
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.207Z | Extended Element | 5333565.7636407763,2184679.8765809326,360.95493459987085 | -89.1454 | -0.000140603 | -179.837 | -0.012700000188651295,-4.3867548281130866e-10,-0.012700000003758942 | 0.012700007446443807,7.6708677676591996,0.016636340932903615
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.233Z | Extended Element | 5333565.7281807922,2184679.7744404883,360.95279753664585 | -89.1454 | -0.000213442 | -179.837 | -0.012700000415513018,-2.1306984614003118e-10,-0.012699999999943158 | 0.012700010307213993,7.6708678804151962,0.016676149984215943
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.261Z | Extended Element | 5333565.6572608212,2184679.5701595992,360.94886750206172 | -89.1454 | -0.0000466498 | -179.837 | -0.012699999798391367,5.4036552934490096e-11,-0.012699999998692601 | 0.012700003301050197,7.6708681086105743,0.016755768176812826
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.290Z | Extended Element | 5333565.6218008352,2184679.4680191549,360.94638634723026 | -89.1454 | -0.000131531 | -179.837 | -0.012699999934199022,2.8714977808862149e-10,-0.012700000001080028 | 0.01270000720795215,7.6708682204236451,0.016795577203974794
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.318Z | Extended Element | 5333557.8515568497,2184679.0647442918,360.91437688575661 | -89.1454 | 180 | -0.224457 | -0.01270000520430988,1.8496626347022949e-10,-0.012700000010151665 | 0.012700000780617603,7.6708686256435783,0.016749580564948803
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.346Z | Extended Element | 5333557.749565064,2184678.770962839,360.90808598069646 | -89.1454 | 180 | -0.224457 | -0.012700002886584232,1.625618316813097e-10,-0.012700000008135627 | 0.012700000704153627,7.6708690747973804,0.016635080140079968
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.375Z | Extended Element | 5333557.6475732792,2184678.4771813853,360.90181893835722 | -89.1454 | 180 | -0.224457 | -0.01270000196987916,1.5213596441191268e-10,-0.012700000007511498 | 0.012700000410147442,7.6708695239642539,0.016520579719244533
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.402Z | Extended Element | 5333557.5455814945,2184678.1833999315,360.89555770892997 | -89.1454 | -180 | -0.224457 | -0.012700000860634013,8.3095972336168226e-10,-0.012699999999317887 | 0.012699999872779652,7.670869974774658,0.016406079307217779
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.431Z | Extended Element | 5333557.4435897097,2184677.8896184782,360.88929647944519 | -89.1454 | -180 | -0.224457 | -0.01270000014923315,5.2491766482735802e-10,-0.012700000000113697 | 0.012700005572812725,7.6708704226952253,0.016291578869490345
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.461Z | Extended Element | 5333557.3415979268,2184677.595837024,360.88303525008246 | -89.1454 | -180 | -0.224457 | -0.012699999818452025,-4.2887204902056953e-10,-0.012699999998522081 | 0.012700000896803761,7.6708708690147054,0.016177078452776543
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.487Z | Extended Element | 5333557.239096405,2184677.3005873025,360.87677215215092 | -89.1454 | 180 | -0.224457 | -0.01270000942450988,1.3908296734140607e-10,-0.012699999996589405 | 0.012699999873814706,7.6708713197182039,0.016062005813186165
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.514Z | Extended Element | 5333557.203636419,2184677.1984468568,360.87456311532151 | -89.1454 | -180 | -0.224559 | -0.012700001044113346,2.5327584469261609e-10,-0.012700000000511592 | 0.012699999909560979,7.6708715036518615,0.01603313607027447
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.540Z | Extended Element | 5333564.8026751615,2184677.1085748882,360.89715242802606 | -89.1454 | -0.000108436 | -179.825 | -0.01269999981804327,-1.1180625217085633e-10,-0.012700000001182078 | 0.012700005430866933,7.67087176862898,0.016074546842287804
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.567Z | Extended Element | 5333592.5627550147,2184689.9700674908,360.92435638859712 | -89.1454 | -180 | 0.0592707 | -0.012700000229232162,5.3833534843341059e-10,-0.012700000001045009 | 0.012700000491940318,7.6708337197213448,0.016553594301477938
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.593Z | Extended Element | 5333592.4918350428,2184689.7657866012,360.9285993355972 | -89.1454 | -180 | 0.0592707 | -0.012700000424055667,6.4522876616241792e-10,-0.012700000004039766 | 0.012700000063035545,7.6708336387685003,0.01647397588252204
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.620Z | Extended Element | 5333592.4563750587,2184689.6636461569,360.93062198696782 | -89.1454 | -180 | 0.0592707 | -0.012700000302769413,-1.4490248773122743e-10,-0.012700000002566844 | 0.012700003993537851,7.6708335950630016,0.016434166679182308
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.648Z | Extended Element | 5333592.3560897838,2184689.3747802121,360.93656831787433 | -89.1454 | -180 | 0.0592707 | -0.01270000001385189,-1.0771450400364749e-10,-0.012700000000227378 | 0.012700007138705498,7.67083347970304,0.016321581266729928
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.676Z | Extended Element | 5333592.2540980009,2184689.0809987583,360.94238375676093 | -89.1454 | -180 | 0.0592707 | -0.012699999805266924,-9.017526595661426e-11,-0.012700000000397902 | 0.012700008297845603,7.6708333605112289,0.01620708002962154
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.703Z | Extended Element | 5333592.152106218,2184688.787217306,360.94841417480438 | -89.1454 | -180 | 0.0592707 | -0.012700000627666937,-1.1755962261859749e-11,-0.012700000002591383 | 0.012700000332857439,7.6708332413822777,0.016092578793674362
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.730Z | Extended Element | 5333592.0501144323,2184688.4934358518,360.95434042747422 | -89.1454 | -180 | 0.0588506 | -0.012699999805168441,3.6909479105123256e-10,-0.012700000002146524 | 0.012700005205157463,7.6708304460376882,0.016023391598902949
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.755Z | Extended Element | 5333599.6180813592,2184688.3140633167,360.94919129074458 | -89.1454 | 0.000266721 | 179.891 | -0.012700012147440581,1.7991719149090621e-11,-0.012700000000000003 | 0.012699999773488383,7.670832863763632,0.016153582268522253
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.785Z | Extended Element | 5333599.5160895782,2184688.0202818643,360.95523487516971 | -89.1454 | 0.0000241858 | 179.891 | -0.012700001312860691,-2.5859142333872419e-10,-0.012700000001518509 | 0.012700000122040247,7.6708326479589894,0.016268083369803225
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.812Z | Extended Element | 5333599.4135880535,2184687.7250321419,360.96133698738458 | -89.1454 | 0.0000436212 | 179.891 | -0.012700001666175556,-1.329488741627277e-10,-0.012699999999261044 | 0.012700000002754501,7.670832427783643,0.016383156718621471
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.837Z | Extended Element | 5333599.3781280695,2184687.6228916976,360.96334281717975 | -89.1454 | 0.000106166 | 179.891 | -0.01270000472117578,-3.45215077088774e-10,-0.012700000001292858 | 0.01270000029157718,7.6708323550946167,0.016422965866823631
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.867Z | Extended Element | 5333599.3072080975,2184687.418610808,360.96757618821226 | -89.1454 | 0.00000529199 | 179.891 | -0.012700000714575704,7.0349725968235003e-11,-0.012700000000966346 | 0.012700000239098621,7.6708322019660988,0.016502584174368024
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.893Z | Extended Element | 5333599.2717481107,2184687.3164703641,360.96978745042776 | -89.1454 | 0.000151717 | 179.891 | -0.01270000862041689,-1.4591793375154336e-10,-0.012700000003215127 | 0.012700000234812747,7.670832127366201,0.016542393335939227
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.918Z | Extended Element | 5333599.1714628385,2184687.0276044193,360.97559415561949 | -89.1454 | 0.0000704262 | 179.891 | -0.012700003438556396,-1.5393733571502594e-10,-0.012700000002565534 | 0.012700000145097578,7.6708319118280723,0.016654978604274302
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.941Z | Extended Element | 5333599.0694710547,2184686.7338229669,360.98172224295803 | -89.1454 | -0.0000277449 | 179.891 | -0.012699999881476312,-7.4852121886934147e-10,-0.012700000000157342 | 0.012700001565992877,7.6708316966535826,0.01676947968729596
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.967Z | Extended Element | 5333591.2975205574,2184686.3256325941,360.99811074948451 | -89.1454 | -180 | 0.0469347 | -0.012700000299295397,-4.2892972605809894e-10,-0.012700000003099187 | 0.012700003285363075,7.6708315386668096,0.016773801189440642
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:53.992Z | Extended Element | 5333591.1955287727,2184686.0318511399,361.00415577979948 | -89.1454 | 180 | 0.0469347 | -0.01270000673666472,-9.2972346442292879e-11,-0.012700000006920301 | 0.012700000430708009,7.6708314455454678,0.016659299930063081
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.018Z | Extended Element | 5333591.0935369888,2184685.738069687,361.00994347014552 | -89.1454 | 180 | 0.0469347 | -0.012700005009504398,-2.7812904080738852e-10,-0.012700000002539106 | 0.012700000002525183,7.6708313490356792,0.01654479867647941
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.046Z | Extended Element | 5333590.9915452041,2184685.4442882333,361.01590510574727 | -89.1454 | 180 | 0.0469347 | -0.012700003515781003,-2.0528295408442994e-10,-0.012700000002501859 | 0.012699999838976286,7.670831256601927,0.016430297420422992
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.072Z | Extended Element | 5333590.8890436813,2184685.1490385104,361.02189615118601 | -89.1454 | 180 | 0.0469347 | -0.012700001168006477,5.204370968457459e-10,-0.012700000004561521 | 0.012700000517514323,7.6708311629160679,0.01631522390574508
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.095Z | Extended Element | 5333590.8535836963,2184685.0468980675,361.02390217190765 | -89.1454 | 180 | 0.0469347 | -0.012700007677435773,1.9668006923034242e-10,-0.012700000005641143 | 0.012699999955700689,7.6708311301670644,0.016275414684853693
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.120Z | Extended Element | 5333590.7826637244,2184684.8426171779,361.0280984730914 | -89.1454 | 180 | 0.0469347 | -0.012700003063288664,-3.1586538944891429e-10,-0.01270000000028422 | 0.012700000036152898,7.6708310648000664,0.01619579625952235
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.149Z | Extended Element | 5333590.7472037384,2184684.740476734,361.0301970362741 | -89.1454 | 180 | 0.0469347 | -0.012700002285468149,5.7503087428147152e-10,-0.012700000000738973 | 0.012699999865356066,7.6708310323125017,0.016155987043253613
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.178Z | Extended Element | 5333590.6469184663,2184684.4516107896,361.03563857313435 | -89.1454 | 180 | 0.0469347 | -0.012700008693553443,1.2405054757304238e-10,-0.012699999999431569 | 0.012700000127933982,7.6708309403089761,0.016043401610801981
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.204Z | Extended Element | 5333598.2148853969,2184684.272238255,361.03017574843801 | -89.1454 | -0.000213951 | 179.904 | -0.012700000431528823,-5.7463145356027672e-10,-0.012699999999886318 | 0.012700008389958601,7.6708307641413889,0.016088260264369179
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.231Z | Extended Element | 5333598.1128936084,2184683.9784568013,361.03253666441992 | -89.1454 | -0.0000352169 | 179.904 | -0.012700000533418522,6.1741908666199505e-10,-0.012700000002146862 | 0.012700001142011579,7.6708305717376275,0.016202761414296184
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.259Z | Extended Element | 5333598.0109018264,2184683.6846753475,361.03270024199043 | -89.1454 | -0.00000685535 | 179.904 | -0.012700000639435497,2.5863144946667505e-10,-0.012699999999147353 | 0.012700000075820254,7.670830378736512,0.016317262539681042
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.285Z | Extended Element | 5333597.9089100417,2184683.3908938942,361.0307048915372 | -89.1454 | 0.0000237833 | 179.904 | -0.012700002301923556,8.6612213682633712e-11,-0.012699999999658951 | 0.012700000094618615,7.6708301868759818,0.016431763663417403
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.314Z | Extended Element | 5333597.8069182578,2184683.0971124396,361.02699925047972 | -89.1454 | 0.0000534191 | 179.904 | -0.012700003746745354,9.6252015033115407e-12,-0.012700000001294214 | 0.012699999821421974,7.6708299951103474,0.01654626480465661
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.343Z | Extended Element | 5333597.7044167351,2184682.8018627185,361.02159385318868 | -89.1454 | -0.0000555859 | 179.904 | -0.012700000931411985,-5.5122326575876797e-10,-0.012700000010598719 | 0.012700000759787325,7.6708298009632996,0.016661338201196477
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.371Z | Extended Element | 5333597.6689567519,2184682.6997222737,361.01962398882989 | -89.1454 | -0.0000642562 | 179.904 | -0.012700000251454934,4.7922481579448172e-10,-0.01270000000322815 | 0.012700003569321588,7.6708297352302175,0.016701147363371107
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.400Z | Extended Element | 5333597.5980367763,2184682.4954413851,361.01568425989331 | -89.1454 | 0.0000368274 | 179.904 | -0.012700002733129583,3.8614732438220411e-10,-0.012699999998465229 | 0.012700000143200635,7.6708295997121203,0.016780765709259075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.429Z | Extended Element | 5333597.5625767922,2184682.3933009407,361.01371439552332 | -89.1454 | -0.0000510923 | 179.904 | -0.012700000269309208,-4.3404172856054271e-10,-0.012700000003921788 | 0.012700001646891144,7.6708295340457671,0.016820574891842369
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.456Z | Extended Element | 5333589.7923328048,2184681.9900260773,361.01680010109447 | -89.1454 | -180 | 0.0345986 | -0.012700000502990878,-1.3730414263549369e-11,-0.012700000003367407 | 0.012700001173607421,7.6708294581717817,0.016724623937500963
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.481Z | Extended Element | 5333589.6903410219,2184681.6962446244,361.0110197770519 | -89.1454 | -180 | 0.0345986 | -0.012699999939601442,2.012710207102931e-10,-0.012700000006283699 | 0.012700008176318212,7.6708293878176219,0.016610122667634276
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.504Z | Extended Element | 5333589.5883492371,2184681.4024631707,361.00523945301046 | -89.1454 | -180 | 0.0345986 | -0.01270000009896307,1.8260338140643111e-10,-0.012700000003282797 | 0.012700003963753544,7.670829319130986,0.016495621386944204
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.531Z | Extended Element | 5333589.4863574514,2184681.1086817165,360.9994591291088 | -89.1454 | -180 | 0.0345986 | -0.012700000133790875,3.2485503170782216e-10,-0.012700000000397912 | 0.012700004634580707,7.6708292496523294,0.016381120114774671
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.560Z | Extended Element | 5333589.3843656685,2184680.8149002637,360.99388675137743 | -89.1454 | -180 | 0.0345986 | -0.012699999784083696,2.8405991442269616e-10,-0.012699999999886318 | 0.012700005937962231,7.6708291799932464,0.016266618841561144
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.586Z | Extended Element | 5333589.2823738847,2184680.5211188095,360.98789848111852 | -89.1454 | -180 | 0.0345986 | -0.012699999976362585,-1.7024772934056399e-10,-0.012700000000113683 | 0.012700006459436051,7.6708291099208079,0.016152117565280181
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.614Z | Extended Element | 5333589.1798723638,2184680.225869087,360.98208926812515 | -89.1454 | -180 | 0.0345986 | -0.012700000223509951,8.0302248128064554e-10,-0.012700000004090037 | 0.012700006697554238,7.6708290412799496,0.01603704403878731
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.642Z | Extended Element | 5333589.144412376,2184680.1237286432,360.98007185648345 | -89.1454 | -180 | 0.0343144 | -0.012700000154699907,2.5488008914970376e-10,-0.012700000000056852 | 0.012700004375253081,7.6708263528483673,0.01602754979036872
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.670Z | Extended Element | 5333596.7434511185,2184680.0338566732,360.96854189359772 | -89.1454 | -0.000105717 | 179.916 | -0.012700000000880568,-9.2722052292666569e-11,-0.012699999999829473 | 0.012700004767491023,7.670828880168779,0.01609954588795515
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.695Z | Extended Element | 5333596.7079911325,2184679.9317162293,360.96621997568371 | -89.1454 | -0.000153241 | 179.916 | -0.01270000003392978,3.0212166052627875e-11,-0.01270000000017053 | 0.012700006641790426,7.6708288221176915,0.016139355079213456
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.720Z | Extended Element | 5333596.6077058595,2184679.6428502845,360.96066192438286 | -89.1454 | -0.0000722406 | 179.916 | -0.01270000018142217,5.5053683825484953e-10,-0.012699999999658942 | 0.012700004110112288,7.6708286566986255,0.016251940438046782
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.749Z | Extended Element | 5333596.5057140756,2184679.3490688321,360.95494352579362 | -89.1454 | -0.000142691 | 179.916 | -0.012699999890143886,-2.4727908612543046e-10,-0.012699999999658942 | 0.012700007500832068,7.6708284890077589,0.016366441607929546
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.776Z | Extended Element | 5333596.4037222909,2184679.0552873779,360.94924898993401 | -89.1454 | -0.000233003 | 179.916 | -0.012700000063569557,2.6018320827295892e-10,-0.0126999999992042 | 0.012700010903685091,7.6708283216685729,0.01648094278106094
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.803Z | Extended Element | 5333596.301730508,2184678.7615059237,360.94356026697557 | -89.1454 | 0.000123619 | 179.916 | -0.012700006267141127,-1.3587684433046079e-10,-0.012700000003093823 | 0.012700000172875569,7.6708281534289187,0.016595443945633243
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.831Z | Extended Element | 5333596.1997387223,2184678.46772447,360.93787154396159 | -89.1454 | -0.0000496743 | 179.916 | -0.012700000393164238,1.498171586476588e-10,-0.012699999999772638 | 0.012700002944695907,7.6708279858649204,0.016709945115601258
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.856Z | Extended Element | 5333596.0977469385,2184678.1739430167,360.93218282106136 | -89.1454 | -0.0000108459 | 179.916 | -0.012699999819440824,-8.8490227691828976e-10,-0.012700000004621216 | 0.012700002332988845,7.6708278179409639,0.016824446299462118
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.885Z | Extended Element | 5333588.3252867041,2184677.7642843756,360.93349389983138 | -89.1454 | -180 | 0.0222626 | -0.012700000586084814,-5.48694304961127e-10,-0.012699999999772629 | 0.012700000605210824,7.6708277677286612,0.01671826627744883
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.910Z | Extended Element | 5333588.2898267182,2184677.6621439327,360.93144684048053 | -89.1454 | 180 | 0.0222626 | -0.012700007636022298,-1.8414551626449726e-10,-0.012700000006645394 | 0.012700000485318969,7.6708277528408839,0.016678457056649779
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.934Z | Extended Element | 5333588.2189067472,2184677.4578630426,360.92755153795144 | -89.1454 | 180 | 0.0222626 | -0.012700012862342853,3.8225722738797047e-10,-0.012700000002740363 | 0.012700000257656694,7.6708277209788935,0.016598838603751973
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.945Z | Line | 5333551.0178245474,2184690.3156719543,360.97922642779275 | 0 | 0 | 0 | 0,-0.4825472766533494,0 | 0.007197914645075798,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.954Z | Complex Chain | 5333551.0252177101,2184689.8146649525,360.97922636254145 | 0 | 0 | 0 | -4.6807181350886822,-13.482538670767099,-0.021477599138506775 | 0,0,0.11485454690125607
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.964Z | Bspline Curve | 5333546.3515022388,2184675.8680387144,360.95774876340801 | 0 | 0 | 0 | -0.0071979155763983727,0,0 | 0,0.48254728317260742,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.975Z | Line String | 5333611.0166063085,2184691.0328234737,360.86667978622086 | 0 | 0 | 0 | -59.996129896491766,-0.89493210939690471,-0.037250340461071119 | 0,0,0.046004489785275382
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.983Z | Line String | 5333611.0188793344,2184690.8804401206,360.86667978649973 | 0 | 0 | 0 | -59.996129898354411,-0.89493210939690471,-0.037250340466073339 | 0,0,0.046004489781353186
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:54.993Z | Line String | 5333610.9967840975,2184690.6768875257,360.86705555462282 | 0 | 0 | 0 | -59.98285336792469,-0.89473407063633204,-0.03739340254611534 | 0,0,0.045913570898562739
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.002Z | Line String | 5333610.9169991305,2184690.4470715253,360.87186740057325 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.038060540662058884 | 0,0,0.045612529338484364
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.011Z | Line String | 5333610.689279533,2184689.7911383589,360.88577591298173 | 0 | 0 | 0 | -59.98285336792469,-0.89473407063633204,-0.039964664017816176 | 0,0,0.044753306556287953
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.019Z | Line String | 5333610.5872951346,2184689.4973781845,360.89200484978574 | 0 | 0 | 0 | -59.982853366062045,-0.89473407017067075,-0.040817427133674755 | 0,0,0.044368502970485224
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.026Z | Line String | 5333610.485310738,2184689.2036180105,360.89824056675553 | 0 | 0 | 0 | -59.982853366993368,-0.89473407063633204,-0.041670190246350103 | 0,0,0.043983699384739339
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.035Z | Line String | 5333610.3833263414,2184688.9098578361,360.90449705195505 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.042522008818878021 | 0,0,0.043599840342437801
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.045Z | Line String | 5333610.2813419448,2184688.6160976617,360.91066781491543 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.043351873335950586 | 0,0,0.043237935356387425
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.054Z | Line String | 5333610.1793575473,2184688.3223374872,360.91693825263781 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.044181737848987268 | 0,0,0.042876030370280205
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.064Z | Line String | 5333610.0773731507,2184688.0285773128,360.92307988839787 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.045011602365434555 | 0,0,0.042514125384172985
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.073Z | Line String | 5333549.9731801441,2184686.7843314097,360.88446478127133 | 0 | 0 | 0 | 0,0,0 | 59.98285336792469,0.89473407017067075,0.088082499590370844
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.083Z | Line String | 5333609.8346938724,2184687.3295536465,360.93784760125732 | 0 | 0 | 0 | -59.982853366993368,-0.89473406970500946,-0.046986325241221039 | 0,0,0.041652946189969953
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.093Z | Line String | 5333609.7327094758,2184687.0357934721,360.9440536367261 | 0 | 0 | 0 | -59.982853366993368,-0.89473406970500946,-0.047816189758350447 | 0,0,0.041291041203862733
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.102Z | Line String | 5333609.6307250783,2184686.7420332977,360.9502596718421 | 0 | 0 | 0 | -59.982853366993368,-0.89473406970500946,-0.048646054271216599 | 0,0,0.040929136217698669
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.112Z | Line String | 5333609.5287406817,2184686.4482731232,360.95646570669817 | 0 | 0 | 0 | -59.98285336792469,-0.89473406923934817,-0.049475918787493356 | 0,0,0.040567231231534606
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.120Z | Line String | 5333609.4267562851,2184686.1545129493,360.96271161902661 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.050305783304395391 | 0,0,0.040205326245370543
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.131Z | Line String | 5333609.3247718876,2184685.8607527749,360.96887777565962 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.051135647817204699 | 0,0,0.039843421259149636
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.139Z | Line String | 5333609.222787491,2184685.5669926004,360.97508381004593 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.05196551233387936 | 0,0,0.039481516272928729
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.150Z | Line String | 5333549.1185944844,2184684.3227466973,360.9295171450936 | 0 | 0 | 0 | 0,0,0 | 59.98285336792469,0.89473407017067075,0.092003800446946116
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.157Z | Line String | 5333608.9801082136,2184684.8679689341,360.98981751516396 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.053940235205800491 | 0,0,0.038620337082647893
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.165Z | Line String | 5333608.878123817,2184684.5742087597,360.99504461977568 | 0 | 0 | 0 | -59.982853368856013,-0.89473406923934817,-0.054759316284332726 | 0,0,0.038269215534455725
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.173Z | Line String | 5333608.7761394205,2184684.2804485857,360.99834406336925 | 0 | 0 | 0 | -59.982853369787335,-0.89473406970500946,-0.055566282199720263 | 0,0,0.037930209148669292
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.183Z | Line String | 5333608.6741550239,2184683.9866884113,360.99965002425978 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.056373248107888685 | 0,0,0.037591202763053388
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.193Z | Line String | 5333608.5721706254,2184683.6929282369,360.99901877706543 | 0 | 0 | 0 | -59.982853366993368,-0.89473406970500946,-0.057180214028619503 | 0,0,0.037252196373174229
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.202Z | Line String | 5333608.4701862279,2184683.399168063,360.99640064847233 | 0 | 0 | 0 | -59.982853366062045,-0.89473407017067075,-0.05798717994053959 | 0,0,0.036913189986364614
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.211Z | Line String | 5333608.3682018314,2184683.1054078885,360.9918636729679 | 0 | 0 | 0 | -59.982853366062045,-0.89473407017067075,-0.058794145856950308 | 0,0,0.036574183600464494
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.221Z | Line String | 5333548.2640088256,2184681.8611619854,360.92559349589311 | 0 | 0 | 0 | 0,0,0 | 59.982853366062045,0.89473407017067075,0.095925101304771943
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.230Z | Line String | 5333608.125522553,2184682.4063842222,360.97879784026827 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.060714379857301992 | 0,0,0.035767493288744845
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.239Z | Line String | 5333608.0235381555,2184682.1126240478,360.97332450119887 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.061521345770302105 | 0,0,0.035428486903072098
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.249Z | Line String | 5333607.9215537589,2184681.8188638738,360.96778759641597 | 0 | 0 | 0 | -59.982853366993368,-0.89473407063633204,-0.062328311687281257 | 0,0,0.035089480517342508
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.259Z | Line String | 5333607.8195693623,2184681.5251036994,360.96230530526441 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.063135277603521445 | 0,0,0.034750474131726605
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.267Z | Line String | 5333607.7175849658,2184681.231343525,360.95677735221335 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.063942243516464714 | 0,0,0.034411467745997015
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.277Z | Line String | 5333607.6156005682,2184680.937583351,360.95127223012923 | 0 | 0 | 0 | -59.982853366993368,-0.89473407063633204,-0.064749209433387023 | 0,0,0.034072461360381112
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.285Z | Line String | 5333607.5136161717,2184680.6438231766,360.94576710836679 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.06555617534962721 | 0,0,0.033733454974594679
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.294Z | Line String | 5333547.409423165,2184679.3995772735,360.87270089705936 | 0 | 0 | 0 | 0,0,0 | 59.982853366993368,0.89473406970500946,0.099846402161176684
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.303Z | Line String | 5333607.2709368933,2184679.9447995103,360.93262374951212 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.067432888408291092 | 0,0,0.032970285593819426
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.313Z | Line String | 5333607.1689524967,2184679.6510393359,360.9270957291256 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.068216955725404205 | 0,0,0.032654177807785345
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.322Z | Line String | 5333607.0669680992,2184679.3572791619,360.92156770775273 | 0 | 0 | 0 | -59.982853366993368,-0.89473407063633204,-0.069001023042460474 | 0,0,0.032338070021637577
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.332Z | Line String | 5333606.9649837026,2184679.0635189875,360.91603968728663 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.069785090358777779 | 0,0,0.032021962235432966
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.341Z | Line String | 5333606.8629993061,2184678.7697588131,360.91051166652539 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.070569157671570792 | 0,0,0.031705854449342041
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.350Z | Line String | 5333606.7610149086,2184678.4759986391,360.90501352260509 | 0 | 0 | 0 | -59.982853366993368,-0.89473407063633204,-0.071353224988456532 | 0,0,0.03138974666313743
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.360Z | Line String | 5333606.659030512,2184678.1822384647,360.89952183284345 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.07213729230448962 | 0,0,0.031073638876989662
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.368Z | Line String | 5333546.5548375063,2184676.9379925611,360.81980829704861 | 0 | 0 | 0 | 0,0,0 | 59.982853366062045,0.89473407017067075,0.10376770302161731
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.377Z | Line String | 5333606.4313109163,2184677.5263052979,360.88711218205054 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.073888025734618168 | 0,0,0.030367806027186361
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.387Z | Line String | 5333606.3515259475,2184677.2964892979,360.88278747194568 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.074501421388617928 | 0,0,0.030120506925356949
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.396Z | Line String | 5333606.3427072493,2184677.0931347399,360.88259900474793 | 0 | 0 | 0 | -59.996129900217056,-0.89493210939690471,-0.074647210611942683 | 0,0,0.03008528409856126
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.405Z | Line String | 5333606.3449802762,2184676.9407513868,360.88259900608136 | 0 | 0 | 0 | -59.996129900217056,-0.89493210939690471,-0.074647210612909021 | 0,0,0.030085284099072851
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.414Z | Line | 5333550.9670300968,2184690.3149142787,360.97922642777326 | 0 | 0 | 0 | 0,-0.4825472766533494,0 | 0.0071979137137532234,0,0
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.423Z | Bspline Curve | 5333546.3007077873,2184675.8672810392,360.95774876340801 | 0 | 0 | 0 | -0.0071979155763983727,0,0 | 0,0.48254728270694613,0
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.433Z | Bspline Curve | 5333611.0211523604,2184690.7280567777,361.01655824630541 | 0 | 0 | 0 | -0.007197914645075798,0,0 | 0,0.48254728503525257,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.441Z | Complex Chain | 5333611.0209571095,2184690.7465164927,361.01655824628961 | 0 | 0 | 0 | -4.6807181350886822,-13.482538669835776,0 | 0,0,0.13392158842566459
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:55.448Z | Bspline Curve | 5333606.3404342234,2184677.2455181088,361.03250036706692 | 0 | 0 | 0 | 0,-0.48254728456959128,0 | 0.0071979155763983727,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.386Z | Line String | 5333526.2628951557,2184682.7574010864,360.9953936136443 | 0 | 0 | 0 | 0,0,0 | 104.71784014813602,1.5620233807712793,0.19266059469600805
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.398Z | Line String | 5333611.0162274707,2184691.058220692,360.91963939705198 | 0 | 0 | 0 | -59.996129898354411,-0.89493211032822728,-0.03725066304525626 | 0,0,0.046004344220193616
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.407Z | Line String | 5333611.0196370091,2184690.8296456621,360.91963939696439 | 0 | 0 | 0 | -59.996129897423089,-0.89493210986256599,-0.037250663053214339 | 0,0,0.046004344217692505
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.417Z | Line String | 5333610.9524591118,2184690.5492119626,360.92368377561451 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.03776435744094897 | 0,0,0.045746180013679805
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.427Z | Line String | 5333610.8815391399,2184690.344931074,360.92799953203138 | 0 | 0 | 0 | -59.98285336792469,-0.89473407063633204,-0.038357369094512705 | 0,0,0.045478587516981861
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.435Z | Line String | 5333610.8106191689,2184690.1406501844,360.93212769963941 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.038950380755693459 | 0,0,0.045210995016930156
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.443Z | Line String | 5333610.739699197,2184689.9363692952,360.93644832201483 | 0 | 0 | 0 | -59.982853368856013,-0.89473407063633204,-0.039543392416931056 | 0,0,0.04494340251687845
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.451Z | Line String | 5333610.6383058,2184689.6443114616,360.94274351570897 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.040391213765587963 | 0,0,0.044560828869805391
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.460Z | Line String | 5333610.5363140153,2184689.3505300079,360.94887055146091 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.041244038658135196 | 0,0,0.044175997407819523
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.468Z | Line String | 5333610.4343222305,2184689.0567485546,360.95607273932234 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.042096863543974905 | 0,0,0.043791165949073729
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.477Z | Line String | 5333610.3323304467,2184688.7629671013,360.96188758696252 | 0 | 0 | 0 | -59.982853368856013,-0.89473407063633204,-0.042937285097252698 | 0,0,0.043418737823003539
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.485Z | Line String | 5333610.2303386619,2184688.4691856476,360.9677437930581 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.043767209724080658 | 0,0,0.04305680662270106
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.494Z | Line String | 5333610.1283468781,2184688.1754041938,360.97396361237656 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.044597134351533896 | 0,0,0.042694875422455425
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.503Z | Line String | 5333610.0269534811,2184687.8833463602,360.98014769314665 | 0 | 0 | 0 | -59.982853369787335,-0.89473406970500946,-0.04542218979821655 | 0,0,0.042335067677640836
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.513Z | Line String | 5333609.9560335092,2184687.679065471,360.9842156460013 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.045999277760927271 | 0,0,0.042083398872080124
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.522Z | Line String | 5333609.8851135373,2184687.4747845819,360.9885313245926 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.04657636573824675 | 0,0,0.041831730060209793
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.530Z | Line String | 5333609.7837201394,2184687.1827267483,360.99470139622355 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.047401421184304127 | 0,0,0.041471922315281518
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.537Z | Line String | 5333609.6817283556,2184686.888945295,361.00098174810256 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.048231345818919635 | 0,0,0.041109991111795807
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.547Z | Line String | 5333609.5797365708,2184686.5951638413,361.00711436541621 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.049061270442393834 | 0,0,0.040748059911379642
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.554Z | Line String | 5333609.477744787,2184686.3013823875,361.01334718460328 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.049891195077009343 | 0,0,0.040386128707780244
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.564Z | Line String | 5333609.3757530022,2184686.0076009342,361.01952733390243 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.050721119703609929 | 0,0,0.040024197507420922
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.572Z | Line String | 5333609.2737612175,2184685.7138194805,361.02573381792553 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.051551044326743067 | 0,0,0.0396622663070616
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.580Z | Line String | 5333609.1723678205,2184685.4217616473,361.03190388831223 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.052376099772914131 | 0,0,0.039302458562076481
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.589Z | Line String | 5333609.1014478495,2184685.2174807582,361.03621956611062 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.052953187739433361 | 0,0,0.039050789756402082
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.598Z | Line String | 5333609.0305278767,2184685.0131998686,361.04064429057894 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.053530275716298092 | 0,0,0.038799120944474907
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.607Z | Line String | 5333608.9291344788,2184684.7211420354,361.04651197851501 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.054355331168324028 | 0,0,0.038439313198580294
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.615Z | Line String | 5333608.827142695,2184684.4273605817,361.05071986669594 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.05516301688595604 | 0,0,0.038099620908894849
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.623Z | Line String | 5333608.7251509111,2184684.133579128,361.05323240075711 | 0 | 0 | 0 | -59.982853368856013,-0.89473406923934817,-0.055970041251100611 | 0,0,0.037760589967433589
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.630Z | Line String | 5333608.6231591264,2184683.8397976747,361.0535829804287 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.056777065622782175 | 0,0,0.037421559024551243
