Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.521Z | Smart Solid | 5333562.4065582929,2184681.1959105916,338.03303530607059 | 0 | 0 | 0 | -0.16398984133977357,-0.16235190062911864,-11.430038100076061 | 0.16398050263524055,0.16232884534342926,11.430007620015374 | Feature - Feature Definition: No Feature Definition; Feature Name: P13; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P13; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167575 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1071.53 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P13; Top X: 17498529 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1071.53 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498529 us survey foot; Top Y: 7167575 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.593Z | Smart Solid | 5333561.4237592071,2184678.3650292098,338.18852933705864 | 0 | 0 | 0 | -0.7796736245590008,-1.9358082479779113,-11.295374830782801 | 0.77967712096869946,1.9357927352999036,11.295370677969157 | Feature - Feature Definition: No Feature Definition; Feature Name: P14; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P14; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167571 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 9.462 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P14; Top X: 17498528 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498528 us survey foot; Top Y: 7167571 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.663Z | Smart Solid | 5333561.7762763519,2184689.2918719836,338.34192024384049 | 0 | 0 | 0 | -1.3964314624023899,-2.5901773388718796,-11.180332936832961 | 1.3964353507935408,2.5901734766115059,11.180329961741586 | Feature - Feature Definition: No Feature Definition; Feature Name: P15; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P15; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167594 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1073.56 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: -9.462 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 45 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P15; Top X: 17498531 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: -9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1073.56 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498531 us survey foot; Top Y: 7167594 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 45 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.735Z | Smart Solid | 5333560.8018592838,2184686.4851460503,338.18852933705864 | 0 | 0 | 0 | -1.9357898896923773,-0.77967860456445759,-11.295374830840988 | 1.9358110935854371,0.77967214096324233,11.295370677910967 | Feature - Feature Definition: No Feature Definition; Feature Name: P16; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P16; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167590 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P16; Top X: 17498530 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498530 us survey foot; Top Y: 7167590 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.808Z | Smart Solid | 5333560.4353365507,2184685.4293472185,338.18852933705864 | 0 | 0 | 0 | -1.9358035140103214,-0.7796666142519707,-11.295374830840988 | 1.9357974692674931,0.77968413127572922,11.295370677910967 | Feature - Feature Definition: No Feature Definition; Feature Name: P17; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P17; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167587 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P17; Top X: 17498529 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498529 us survey foot; Top Y: 7167587 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.875Z | Smart Solid | 5333560.0687985774,2184684.3735788669,338.18852933705864 | 0 | 0 | 0 | -1.9358018981656544,-0.77968510286772197,-11.295374830840988 | 1.93579908511216,0.77966564265997795,11.295370677910967 | Feature - Feature Definition: No Feature Definition; Feature Name: P18; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P18; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167583 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P18; Top X: 17498527 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498527 us survey foot; Top Y: 7167583 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Civil Custom Graphics | [CivilDesignerProductsDynamic].[Supports\Pier\Pier_steel_piles] | Feature - Feature Definition: Pier_steel_piles; Feature Name: Pier1; Material - Footing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Concrete Pad Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Cap Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Column Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Pile Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); [CivilDesignerProductsDynamic].[Supports\Pier\Pier_steel_piles] - In Spatial Index: yes; Last Modified: 2025-09-30T17:15:52.048Z; User Label: Civil Custom Graphics; Origin: 0,0,0; Yaw: 0; Pitch: 0; Roll: 0; Bounding Box Low: 1.7976931348623157e+308,1.7976931348623157e+308,1.7976931348623157e+308; Bounding Box High: -1.7976931348623157e+308,-1.7976931348623157e+308,-1.7976931348623157e+308; Pier - Name: Pier1; Template Name: IA Filleted Column Tee; Substructure Placement Rule - Elevation Constraints: SELECT to Edit; Horizontal Offset: 0 us survey foot; Apply Skew To Solids: no; Substructure Template: IA Filleted Column Tee; Conform BackWall With Deck Top: no; Orientation: 1; Conform Notch With Approach Slab: no; Integral: no; Conform Corbel With Approach Slab Bottom: no; Conform Corbel Bottom With Approach Slab: no; Pier properties - ItemTypes - Pile material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Name: Pier1; Template name: IA Filleted Column Tee; Cap material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Footing material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Column material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Cap build order: 1; Column build order: 1; Pile build order: 1; Footing build order: 1; Build Order - Pile Build Order: 1; Pier Cap Build Order: 1; Footing Build Order: 1; Column Build Order: 1; Concrete Pad Build Order: 1
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:52.986Z | Smart Solid | 5333559.7022606041,2184683.3177800355,338.18852933705864 | 0 | 0 | 0 | -1.9358002804583423,-0.77967311441788023,-11.295374830724629 | 1.9358007028194721,0.77967763110981969,11.295370678027325 | Feature - Feature Definition: No Feature Definition; Feature Name: P19; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P19; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167580 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P19; Top X: 17498526 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498526 us survey foot; Top Y: 7167580 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.062Z | Smart Solid | 5333559.3357226308,2184682.2619964438,338.18852933705864 | 0 | 0 | 0 | -1.9357986655449979,-0.77967636380234306,-11.29537483078278 | 1.9358023177328165,0.77967438172535686,11.295370677969174 | Feature - Feature Definition: No Feature Definition; Feature Name: P20; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P20; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167576 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1072.55 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P20; Top X: 17498525 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1072.55 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498525 us survey foot; Top Y: 7167576 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.132Z | Smart Solid | 5333558.361320802,2184679.4552705106,338.34192024384049 | 0 | 0 | 0 | -2.6089682073888483,-1.3669229848856808,-11.180332936832833 | 2.6089586972809986,1.366918400780236,11.180329961741711 | Feature - Feature Definition: No Feature Definition; Feature Name: P21; Solid - Surface Area: 373.041 us survey square foot; Volume: 8.61033 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P21; Support Name: Pier1; Pier Pile - ItemTypes - Pile Length: 75 us survey foot; Top Y: 7167573 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1073.56 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.53 us survey foot; Bottom Angle Adjustment Y: 9.462 deg; Bottom Angle Adjustment X: -9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: -45 deg; Volume: 8.61038 ft3; Surface Area: 373.041 us survey square foot; Pile Name: P21; Top X: 17498524 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier1; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 75 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.53 us survey foot; Bottom Elevation: 1073.56 us survey foot; Longitudinal Angle: -9.462 deg; Embed Length: 1 us survey foot; Top X: 17498524 us survey foot; Top Y: 7167573 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: -45 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.196Z | Smart Solid | 5333594.2258216916,2184683.7711709421,358.94540513081023 | 0 | 0 | 0 | -2.9750221504955165,-7.110534619479365,-0.91441706883394724 | 2.9750394504381861,7.110532786231488,0.9143865887733682 | Feature - Feature Definition: No Feature Definition; Feature Name: 1; Solid - Surface Area: 904.088 us survey square foot; Volume: 987 ft³ (us survey); Cap - Cap Type: Tapered; Station: 170+83.10000; Elevation Left: 1180.64 us survey foot; Length: 48 us survey foot; Width: 4 us survey foot; Height: 6 us survey foot; Left Taper Length: 13.75 us survey foot; Elevation Right: 1180.64 us survey foot; Fillet Radius: 0 us survey foot; Chamfer Length: 0 us survey foot; Minimum Height: 3 us survey foot; Right Taper Length: 13.75 us survey foot; Pier Cap - ItemTypes - Chamfer Length: 0 us survey foot; Width: 4 us survey foot; Elevation Left: 1180.64; Length: 48 us survey foot; Height: 6 us survey foot; Elevation Right: 1180.64; Fillet Radius: 0 us survey foot; Ledge Width: 0 us survey foot; Support Name: Pier2; Ledge Depth: 0 us survey foot; Minimum Height: 3 us survey foot; Left Delta: 13.75 us survey foot; Right Delta: 13.75 us survey foot; Volume: 987.006 ft3; Surface Area: 904.088 us survey square foot; Bottom Length: 49 us survey foot; Bottom Width: 3.5 us survey foot; Footing Offset: 0 us survey foot; BackWall Depth: 0 us survey foot; Horizontal Offset: 0 us survey foot; BackWall Width: 0 us survey foot; Vertical Offset: 0 us survey foot; Name: 1; Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Material - Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; General - Name: 1; Support Name: Pier2
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.330Z | Smart Solid | 5333594.2258369317,2184683.7711709421,354.22099568199133 | 0 | 0 | 0 | -1.5050872220044802,-3.0558982335241813,-3.8112348904809172 | 1.5050740403055649,3.0558963981776519,3.811204410420387 | Feature - Feature Definition: No Feature Definition; Feature Name: 1; Solid - Surface Area: 1234.62 us survey square foot; Volume: 1684.21 ft³ (us survey); Material - Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; General - Name: 1; Support Name: Pier2; Column - Length: 25 us survey foot; Column Type: Rect-Fillet; Overhang: 0 us survey foot; Top Elevation: 1174.64 us survey foot; Fillet Radius: 2.5 us survey foot; Overhang Type: Auto; Width: 20 us survey foot; Depth: 3.5 us survey foot; Pier Column - ItemTypes - Width: 20 us survey foot; Diameter Y: 0 us survey foot; Length: 25 us survey foot; Diameter X: 0 us survey foot; Diameter: 0 us survey foot; Depth: 3.5 us survey foot; Overhang: 0 us survey foot; Bevel X: 0 us survey foot; Bevel Y: 0 us survey foot; Fillet Radius: 2.5 us survey foot; Chamfer Length: 0 us survey foot; Top Elevation: 1174.64 us survey foot; Volume: 1684.22 ft3; Surface Area: 1234.62 us survey square foot; Support Name: Pier2; Name: 1; Material: Structural Concrete (Bridge) - CCS & PPCB Bridges
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.692Z | Smart Solid | 5333594.2258216916,2184683.7711709421,349.8013868427737 | 0 | 0 | 0 | -2.97719830885445,-4.1990610067615854,-0.60961645923276908 | 2.977215611335231,4.1990591739304364,0.60958597917210877 | Feature - Feature Definition: No Feature Definition; Feature Name: 1; Solid - Surface Area: 1001.53 us survey square foot; Volume: 1197.56 ft³ (us survey); General - Name: 1; Support Name: Pier2; Pier Footing - ItemTypes - Slope: 0; Rotation Angle: 0 deg; Length: 25 us survey foot; Surface Area: 1001.53 us survey square foot; Drill shaft diameter: 0 us survey foot; Association Type: Default; Top Elevation: 1149.64; Associated column: 1; Has Concrete Pad: False; Width: 12 us survey foot; Height: 4 us survey foot; Sloped Extra Top Length: 0 us survey foot; Extra Length: 0 us survey foot; Slope Height: 0 us survey foot; Sloped Top Width: 0 us survey foot; Sloped Top Length: 0 us survey foot; Drill Shaft Height: 0 us survey foot; Volume: 1197.57 ft3; Name: 1; Support Name: Pier2; Footing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Concrete Pad Material: Structural Concrete (Bridge) - CCS & PPCB Bridges; Footing - Footing Type: Rectangular Isolated; Bottom Elevation: 1145.64 us survey foot; Assoc. Column ID: 1; Sloped: no; Footing Association: Default; Concrete Pad: no; Top Elevation: 1149.64 us survey foot; Rotation: 0 deg; Height: 4 us survey foot; Slope Depth: 0 us survey foot; Top Width: 0 us survey foot; Top Length: 0 us survey foot; Width: 12 us survey foot; Length: 25 us survey foot; Material - Footing Material: Structural Concrete (Bridge) - CCS & PPCB Bridges
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.789Z | Smart Solid | 5333599.3218592834,2184687.7746659894,336.89262382524765 | 0 | 0 | 0 | -2.926682100162699,-1.5182121276337583,-12.663141563186297 | 2.9267015576597144,1.5182116791235996,12.663154447332532 | Feature - Feature Definition: No Feature Definition; Feature Name: P1; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P1; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167592 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1063.94 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: -9.462 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: -45 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P1; Top X: 17498642 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: -9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1063.94 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498642 us survey foot; Top Y: 7167592 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: -45 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.862Z | Smart Solid | 5333598.2664109729,2184684.734478029,336.71879603759209 | 0 | 0 | 0 | -2.1724792402198259,-0.86184109891316241,-12.798650975042598 | 2.1724792821499292,0.86184466350823641,12.798632044491779 | Feature - Feature Definition: No Feature Definition; Feature Name: P2; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P2; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167589 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P2; Top X: 17498640 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498640 us survey foot; Top Y: 7167589 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:53.930Z | Smart Solid | 5333597.8998729996,2184683.6786944373,336.71879603759209 | 0 | 0 | 0 | -2.1724776234438363,-0.86184434876328653,-12.798650975042598 | 2.1724808989259188,0.86184141365811229,12.798632044491779 | Feature - Feature Definition: No Feature Definition; Feature Name: P3; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P3; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167585 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P3; Top X: 17498639 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498639 us survey foot; Top Y: 7167585 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.000Z | Smart Solid | 5333597.5333502665,2184682.6229108456,336.71879603759209 | 0 | 0 | 0 | -2.1724912468304578,-0.86184759814774936,-12.798650974984334 | 2.1724672755392973,0.86183816427364945,12.798632044550043 | Feature - Feature Definition: No Feature Definition; Feature Name: P4; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P4; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167582 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P4; Top X: 17498638 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498638 us survey foot; Top Y: 7167582 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.060Z | Smart Solid | 5333597.1667970531,2184681.5671120142,336.71879603759209 | 0 | 0 | 0 | -2.1724743917545024,-0.86183560736960119,-12.798650975042598 | 2.1724841306152527,0.86185015505179763,12.798632044491779 | Feature - Feature Definition: No Feature Definition; Feature Name: P5; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P5; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167578 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P5; Top X: 17498637 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498637 us survey foot; Top Y: 7167578 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.130Z | Smart Solid | 5333596.8002743199,2184680.5113436626,336.71879603759209 | 0 | 0 | 0 | -2.172488017003769,-0.86185409831365889,-12.798650974984334 | 2.1724705053659861,0.86183166410773993,12.798632044550043 | Feature - Feature Definition: No Feature Definition; Feature Name: P6; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P6; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167575 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 90 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P6; Top X: 17498636 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498636 us survey foot; Top Y: 7167575 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 90 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.197Z | Smart Solid | 5333595.7448107693,2184677.471140462,336.89262382524765 | 0 | 0 | 0 | -1.5520657903526041,-2.9057956035664949,-12.66314156266321 | 1.5520593478785703,2.9058076667856825,12.663154447855616 | Feature - Feature Definition: No Feature Definition; Feature Name: P7; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P7; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167571 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1063.94 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 9.462 deg; Bottom Angle Adjustment X: 9.462 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 45 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P7; Top X: 17498634 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1063.94 us survey foot; Longitudinal Angle: 9.462 deg; Embed Length: 1 us survey foot; Top X: 17498634 us survey foot; Top Y: 7167571 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 45 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.276Z | Smart Solid | 5333596.0238557272,2184688.9502971806,336.71879603759209 | 0 | 0 | 0 | -0.86183536984429265,-2.1724763499040867,-12.798650974926165 | 0.86185039257710616,2.1724821724656689,12.798632044608212 | Feature - Feature Definition: No Feature Definition; Feature Name: P8; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P8; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167594 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: -9.462 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P8; Top X: 17498637 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: -9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498637 us survey foot; Top Y: 7167594 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.344Z | Smart Solid | 5333594.9588976372,2184685.8827381255,336.54256032512063 | 0 | 0 | 0 | -0.16397975139624221,-0.16233479036795864,-12.95404114808224 | 0.16399059258401394,0.16234595561006127,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P9; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P9; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167590 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P9; Top X: 17498636 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498636 us survey foot; Top Y: 7167590 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.405Z | Smart Solid | 5333594.5923749041,2184684.8269545338,336.54256032512063 | 0 | 0 | 0 | -0.16399337385154111,-0.16233804021808276,-12.95404114808224 | 0.16397697012871504,0.16234270575993714,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P10; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P10; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167587 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P10; Top X: 17498635 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498635 us survey foot; Top Y: 7167587 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.476Z | Smart Solid | 5333594.2258216916,2184683.7711709421,336.54256032512063 | 0 | 0 | 0 | -0.1639765197069083,-0.1623412896025456,-12.95404114808224 | 0.16399382427334785,0.16233945637547431,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P11; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P11; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167583 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P11; Top X: 17498634 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498634 us survey foot; Top Y: 7167583 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.545Z | Smart Solid | 5333593.8592989584,2184682.7153721107,336.54256032512063 | 0 | 0 | 0 | -0.1639901458874975,-0.16232929975572,-12.95404114808224 | 0.16398019809275866,0.16235144622229991,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P12; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P12; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167580 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P12; Top X: 17498633 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498633 us survey foot; Top Y: 7167580 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.629Z | Smart Solid | 5333593.492745745,2184681.6596037592,336.54256032512063 | 0 | 0 | 0 | -0.16397328894889696,-0.16234778976845513,-12.95404114808224 | 0.1639970550313592,0.16233295620956478,12.954010668021397 | Feature - Feature Definition: No Feature Definition; Feature Name: P13; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P13; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167576 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1061.64 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 0 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P13; Top X: 17498631 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 0 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1061.64 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498631 us survey foot; Top Y: 7167576 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:10:54.692Z | Smart Solid | 5333592.427787655,2184678.5920447041,336.71879603759209 | 0 | 0 | 0 | -0.86183308767637556,-2.1724840034897213,-12.798650975042598 | 0.86185267474502325,2.1724745188800338,12.798632044491779 | Feature - Feature Definition: No Feature Definition; Feature Name: P14; Solid - Surface Area: 422.75 us survey square foot; Volume: 9.75837 ft³ (us survey); Material - Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); General - Name: P14; Support Name: Pier2; Pier Pile - ItemTypes - Pile Length: 85 us survey foot; Top Y: 7167573 us survey foot; Cap Top Margin: 1.5 us survey foot; Cap Bottom Margin: 1.5 us survey foot; Cap Left Margin: 1.5 us survey foot; Bottom Elevation: 1062.8 us survey foot; Cap Right Margin: 1.5 us survey foot; Template: HP10X57; Top Elevation: 1146.64 us survey foot; Bottom Angle Adjustment Y: 9.462 deg; Bottom Angle Adjustment X: 0 deg; Pile Wall Thickness: 0 us survey foot; Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Pile Diameter: 0 us survey foot; Embed Depth: 1 us survey foot; Thickness Outside: 0.0470832 us survey foot; Thickness Inside: 0.0470832 us survey foot; Rotation Angle: 0 deg; Volume: 9.75843 ft3; Surface Area: 422.75 us survey square foot; Pile Name: P14; Top X: 17498630 us survey foot; Pile Outside Diameter: 0 us survey foot; Support Name: Pier2; Material: Piles, Steel, HP 12 X 53 (CONCRETE ENCASEMENT P10A TYPE 3 and P10L TYPE 3 alsoze); Pile Shape: H Pile; Pile - Bottom Margin: 1.5 us survey foot; Pile Shape: H Pile; Pile Shape Text: H Pile; Pile Length: 85 us survey foot; Top Margin: 1.5 us survey foot; Left Margin: 1.5 us survey foot; Transverse Angle: 9.462 deg; Right Margin: 1.5 us survey foot; Top Elevation: 1146.64 us survey foot; Bottom Elevation: 1062.8 us survey foot; Longitudinal Angle: 0 deg; Embed Length: 1 us survey foot; Top X: 17498630 us survey foot; Top Y: 7167573 us survey foot; Pile Weight: 0 us survey foot; Pier - Pile Width: 0.849998 us survey foot; Pile Depth: 0.832498 us survey foot; Flange Thickness: 0.0470832 us survey foot; Template: HP10X57; Web Thickness: 0.0470832 us survey foot; Rotation: 0 deg
