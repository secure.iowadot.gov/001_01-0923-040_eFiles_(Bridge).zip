Properties of the parts of a building model (IFC4X3_ADD2), part 36 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.956Z | Line | 5333607.4132030141,2184676.8534873244,360.00975718345853 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.849859346402809e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.966Z | Line | 5333607.4132030159,2184676.8534873249,359.70495657389506 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.975Z | Line | 5333607.4132030169,2184676.8534873254,359.46170028729034 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.849859346402809e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.984Z | Line | 5333607.4132030178,2184676.8534873258,359.21844400123126 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.849859346402809e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:54.993Z | Line | 5333607.4085167889,2184677.1676510531,360.97104750668751 | 0 | 0 | 0 | -1.7524085594341159,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.002Z | Line | 5333607.4085167907,2184677.1676510535,360.65061739913398 | 0 | 0 | 0 | -1.7524085594341159,-0.026139797642827034,-6.849859346402809e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.012Z | Line | 5333607.4082781384,2184677.1836502906,360.3301872912408 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.849859346402809e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.021Z | Line | 5333607.4082781393,2184677.1836502911,360.00975718395148 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.032Z | Line | 5333607.4082781412,2184677.1836502915,359.7049565743942 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.040Z | Line | 5333607.4082781421,2184677.183650292,359.46170028800782 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.050Z | Line | 5333607.408278143,2184677.1836502925,359.218444001693 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.849859346402809e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.060Z | Line | 5333607.4110957431,2184676.9947581929,360.98859019557733 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.849859346402809e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.069Z | Line | 5333607.4110957449,2184676.9947581929,360.66816006348949 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.080Z | Line | 5333607.4110957459,2184676.9947581929,360.33018729099388 | 0 | 0 | 0 | -1.7524085585027933,-0.026139797642827034,-6.8499161898216698e-09 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.089Z | Line | 5333608.4493721323,2184676.8927576025,360.18580998050521 | 0 | 0 | 0 | -5.5879354476928711e-09,-1.862645149230957e-09,0 | 0,0,1.6891033782067097
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.099Z | Line String | 5333608.4494431503,2184676.8879965525,360.18700903127245 | 0 | 0 | 0 | -0.016062683425843716,-0.00023677293211221695,-6.3494098867522553e-11 | 0,0.012461839709430933,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.109Z | Line | 5333608.4494431503,2184676.887996553,360.18700903127245 | 0 | 0 | 0 | -0.00018941890448331833,0,0 | 0,0.012698613107204437,2.0065726857865229e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.118Z | Line | 5333608.4415065171,2184676.8878781665,360.18700903124073 | 0 | 0 | 0 | -0.088890289887785912,-0.001325931865721941,-3.5572611523093656e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.129Z | Line | 5333608.344679595,2184676.8864338482,360.18700903085318 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0065726857865229e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.138Z | Line | 5333608.3605528604,2184676.8866706211,360.18700903091673 | 0 | 0 | 0 | -0.00018941890448331833,0,0 | 0,0.012698613107204437,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.151Z | Line | 5333608.3604818424,2184676.8914316706,360.1858099794058 | 0 | 0 | 0 | -6.5192580223083496e-09,-2.3283064365386963e-09,0 | 0,0,1.7045374451602697
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.161Z | Line | 5333608.3526162272,2184676.8865522346,360.18700903088501 | 0 | 0 | 0 | -0.11428751423954964,-0.0017047696746885777,-4.574758349917829e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.169Z | Line | 5333608.2303920798,2184676.8847290785,360.18700903039581 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.177Z | Line | 5333608.2462653453,2184676.8849658514,360.18700903045936 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.012698613107204437,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.184Z | Line | 5333608.2461943273,2184676.889726901,360.18580997897033 | 0 | 0 | 0 | -6.5192580223083496e-09,-2.3283064365386963e-09,0 | 0,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.194Z | Line | 5333608.238328713,2184676.884847465,360.18700903042753 | 0 | 0 | 0 | -0.11428751517087221,-0.0017047692090272903,-4.5730530473520048e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.203Z | Line | 5333608.1161045646,2184676.8830243093,360.18700902993851 | 0 | 0 | 0 | -0.0001894170418381691,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.212Z | Line | 5333608.131977831,2184676.8832610822,360.18700903000206 | 0 | 0 | 0 | -0.00018941890448331833,0,0 | 0,0.012698613107204437,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.221Z | Line | 5333608.131906813,2184676.8880221318,360.18580997851291 | 0 | 0 | 0 | -6.5192580223083496e-09,-2.3283064365386963e-09,0 | 0,0,1.7442250443979788
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.232Z | Line | 5333608.1240411978,2184676.8831426958,360.18700902997023 | 0 | 0 | 0 | -0.12698612734675407,-0.0018941881135106087,-5.0818016461562365e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.243Z | Line | 5333608.0065790303,2184676.8813905725,360.18700902950019 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.253Z | Line | 5333608.025626949,2184676.8816747009,360.18700902957642 | 0 | 0 | 0 | -0.0001894170418381691,0,0 | 0,0.01269861264154315,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.263Z | Line | 5333607.9970550705,2184676.8812485076,360.18700902946205 | 0 | 0 | 0 | -0.15238335356116295,-0.0022730259224772453,-6.0981619753874838e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.273Z | Line | 5333607.8541956758,2184676.8791175466,360.18700902889032 | 0 | 0 | 0 | -0.0001894170418381691,0,0 | 0,0.01269861264154315,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.282Z | Line | 5333607.8732435955,2184676.879401675,360.18700902896654 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.293Z | Line | 5333607.7018123223,2184676.8768445207,360.18700902828044 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0065726857865229e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.301Z | Line | 5333607.720860241,2184676.877128649,360.18700902835667 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.312Z | Line | 5333607.8446717169,2184676.8789754817,360.18700902885223 | 0 | 0 | 0 | -0.15238335449248552,-0.002273025456815958,-6.0987304095760919e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.321Z | Line | 5333607.5494289678,2184676.8745714948,360.18700902767057 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0065726857865229e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.332Z | Line | 5333607.5684768865,2184676.8748556231,360.1870090277468 | 0 | 0 | 0 | -0.0001894170418381691,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.340Z | Line | 5333607.6922883624,2184676.8767024563,360.18700902824236 | 0 | 0 | 0 | -0.15238335449248552,-0.0022730259224772453,-6.0987304095760919e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.350Z | Line | 5333607.5399050079,2184676.8744294303,360.18700902763248 | 0 | 0 | 0 | -0.22857502847909927,-0.003409538883715868,-9.1478113972698338e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.360Z | Line | 5333607.3113299794,2184676.8710198915,360.1870090267177 | 0 | 0 | 0 | -0.22857502941042185,-0.0034095384180545807,-9.1472429630812258e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.369Z | Line | 5333607.3208539393,2184676.8711619563,360.18700902675585 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.379Z | Line | 5333607.339901858,2184676.8714460847,360.18700902683202 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0065726857865229e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.388Z | Line | 5333607.08275495,2184676.867610353,360.18700902580298 | 0 | 0 | 0 | -0.22857502847909927,-0.003409538883715868,-9.1483798314584419e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.400Z | Line | 5333607.0922789099,2184676.8677524175,360.18700902584106 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.410Z | Line | 5333607.1113268286,2184676.8680365458,360.18700902591729 | 0 | 0 | 0 | -0.0001894170418381691,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.420Z | Line | 5333606.8541799216,2184676.8642008142,360.18700902488814 | 0 | 0 | 0 | -0.22857502941042185,-0.0034095384180545807,-9.1478113972698338e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.429Z | Line | 5333606.8637038814,2184676.864342879,360.18700902492628 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.438Z | Line | 5333606.8827518001,2184676.8646270074,360.18700902500251 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.448Z | Line | 5333606.6256048921,2184676.8607912757,360.18700902397336 | 0 | 0 | 0 | -0.22857502847909927,-0.003409538883715868,-9.1478113972698338e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.457Z | Line | 5333606.635128852,2184676.8609333402,360.1870090240115 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.467Z | Line | 5333606.6541767707,2184676.8612174685,360.18700902408773 | 0 | 0 | 0 | -0.0001894170418381691,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.477Z | Line | 5333606.3970298637,2184676.8573817369,360.18700902305858 | 0 | 0 | 0 | -0.22857502941042185,-0.003409538883715868,-9.1472429630812258e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.487Z | Line | 5333606.4065538235,2184676.8575238013,360.18700902309672 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.496Z | Line | 5333606.4256017422,2184676.8578079296,360.187009023173 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,1.9952040020143613e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.504Z | Line | 5333606.1684548343,2184676.853972198,360.18700902214385 | 0 | 0 | 0 | -0.22857502847909927,-0.0034095384180545807,-9.1478113972698338e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.511Z | Line | 5333606.1779787941,2184676.8541142629,360.18700902218194 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.519Z | Line | 5333606.1970267138,2184676.8543983912,360.18700902225817 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.529Z | Line | 5333605.9398798058,2184676.8505626596,360.18700902122907 | 0 | 0 | 0 | -0.22857502941042185,-0.003409538883715868,-9.1483798314584419e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.536Z | Line | 5333605.9494037656,2184676.850704724,360.18700902126716 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.546Z | Line | 5333605.9684516843,2184676.8509888523,360.18700902134339 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.01269861264154315,2.0008883439004421e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.554Z | Line | 5333605.7398766559,2184676.8475793139,360.1870090204286 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.012698612175881863,2.0065726857865229e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.564Z | Line | 5333605.7208287362,2184676.8472951856,360.18700902035243 | 0 | 0 | 0 | -0.00018941797316074371,0,0 | 0,0.012698612175881863,1.9952040020143613e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.573Z | Complex Chain | 5333605.7109190878,2184676.870961627,361.93561059535676 | 0 | 0 | 0 | 0,0,-0.069515831054047794 | 2.7623086618259549,0.041205356828868389,9.2632035375572741e-09
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.583Z | Complex Chain | 5333605.7094510961,2184676.9693756099,361.93561059551172 | 0 | 0 | 0 | 0,0,-0.069515831053990951 | 2.7623086618259549,0.041205356828868389,9.2632603809761349e-09
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.592Z | Line | 5333605.7109190887,2184676.8709616275,361.80861034135626 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294693946838379,1.0856922472157748e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.604Z | Line | 5333605.7109190887,2184676.8709616275,361.71336015085592 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294693946838379,1.0856865628738888e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.612Z | Line | 5333605.7109190896,2184676.8709616275,361.61810996035553 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294693946838379,1.0856922472157748e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.621Z | Line | 5333605.7109190896,2184676.8709616279,361.41490955395471 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294693946838379,1.0856922472157748e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.631Z | Line | 5333605.7109190905,2184676.8709616284,361.28790929995421 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294693946838379,1.0856922472157748e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.638Z | Line | 5333605.7109190915,2184676.8709616284,361.16090904595376 | 0 | 0 | 0 | 0,0,0 | 2.7682975577190518,0.041294693946838379,1.0856922472157748e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.648Z | Line | 5333608.4487749841,2184676.932790366,360.18580997982468 | 0 | 0 | 0 | -5.5879354476928711e-09,-1.862645149230957e-09,0 | 0,0,1.6891033782067097
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.656Z | Line | 5333608.3595590275,2184676.9532971387,360.18580997949863 | 0 | 0 | 0 | -6.5192580223083496e-09,-2.3283064365386963e-09,0 | 0,0,1.7045374451602697
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.667Z | Line | 5333608.2448527962,2184676.979662993,360.18580997911209 | 0 | 0 | 0 | -6.5192580223083496e-09,-2.3283064365386963e-09,0 | 0,0,1.7243812448029985
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.676Z | Line | 5333608.1303914478,2184676.9896120117,360.18580997867281 | 0 | 0 | 0 | -6.5192580223083496e-09,-2.3283064365386963e-09,0 | 0,0,1.7442250443980356
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.686Z | Line | 5333605.6554916846,2184677.182844223,360.93929741466832 | 0 | 0 | 0 | 0,-0.10280074086040258,0 | 1.214860730804503,0,4.6622972149634734e-09
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.697Z | Complex Chain | 5333605.7526676804,2184677.1588283819,360.45041269737828 | 0 | 0 | 0 | -4.6566128730773926e-09,-0.16331763504851801,0 | 0.0024362068772027508,0,0.95426667038807678
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.710Z | Extended Element | 10667157.365458362,4369367.0786433686,0.076931572559246444 | -180 | -2.27906e-07 | -9.36268e-08 | 5333548.834260189,2184689.8005161546,360.98246760799032 | 5333551.7107825289,2184690.2878327128,361.94696446543151
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.719Z | Complex Chain | 5333605.7710261801,2184676.9924621535,361.94393847701144 | 0 | 0 | 0 | -0.0022889178517587544,0,-0.85159357427894788 | 0,0.1534436032999166,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.726Z | Line | 5333605.70865364,2184677.075678885,361.45987457592372 | 0 | 0 | 0 | 0,-0.16062615672126412,0 | 1.8982198908925056,0,7.2848820309445728e-09
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.734Z | Line | 5333605.7075809967,2184677.1475213375,361.09541033978917 | 0 | 0 | 0 | 0,-0.16062615672126412,0 | 1.8982198899611831,0,7.2848820309445728e-09
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.742Z | Line | 5333608.0725170793,2184676.8871360212,361.99252499915792 | 0 | 0 | 0 | 0,0,-0.076225595178527783 | 0.43901059497147799,0.0065487218089401722,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.753Z | Complex Chain | 5333606.4394121692,2184677.100716501,360.45041269967766 | 0 | 0 | 0 | -4.6566128730773926e-09,-0.1633176355141793,0 | 0.0024362059458801761,0,0.95426667038807678
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.762Z | Complex Chain | 5333606.6683269963,2184677.0813458739,360.45041270061341 | 0 | 0 | 0 | -4.6566128730773926e-09,-0.1633176355141793,0 | 0.0024362059458801761,0,0.95426667038807678
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.772Z | Complex Chain | 5333606.897241829,2184677.0619752472,360.45041270235976 | 0 | 0 | 0 | -4.6566128730773926e-09,-0.1633176355141793,0 | 0.0024362068772027508,0,0.95426667038807678
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.783Z | Line | 5333605.7184975715,2184677.0034907423,361.9417837372788 | 0 | 0 | 0 | 0,0,0 | 0.68572508357465267,0.010228617116808891,3.3597302717680577e-09
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.795Z | Line | 5333605.7213735972,2184676.8107726872,361.99099585040165 | 0 | 0 | 0 | -0.0032679745927453041,0,0 | 0,0.21907716989517212,0.0081148721367299004
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.803Z | Line | 5333605.6554916874,2184677.1828442239,360.61886731796204 | 0 | 0 | 0 | 0,-0.10280074086040258,0 | 1.214860730804503,0,4.6622972149634734e-09
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.813Z | Line | 5333606.2104973365,2184677.1200871272,361.03461386766077 | 0 | 0 | 0 | -0.0010181264951825142,0,0 | 0,0.06825504032894969,7.4635408964240924e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.822Z | Line | 5333606.6683269944,2184677.0813458734,361.0346138690158 | 0 | 0 | 0 | -0.0010181264951825142,0,0 | 0,0.06825504032894969,7.4578565545380116e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.832Z | Complex Chain | 5333605.9815825094,2184677.1394577571,360.45041269764687 | 0 | 0 | 0 | -4.6566128730773926e-09,-0.16331763504851801,0 | 0.0024362059458801761,0,0.95426667038807678
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.841Z | Complex Chain | 5333606.2104973393,2184677.1200871281,360.45041269925832 | 0 | 0 | 0 | -4.6566128730773926e-09,-0.1633176355141793,0 | 0.0024362068772027508,0,0.95426667038807678
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.850Z | Complex Chain | 5333605.9999410082,2184676.9730915288,361.94393847727997 | 0 | 0 | 0 | -0.0022889178517587544,0,-0.85159357427894788 | 0,0.1534436032999166,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.861Z | Complex Chain | 5333606.2288558381,2184676.9537209021,361.94393847846135 | 0 | 0 | 0 | -0.0022889178517587544,0,-0.85159357427889104 | 0,0.1534436032999166,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.870Z | Complex Chain | 5333608.4716825569,2184676.8851517253,361.80861035210512 | 0 | 0 | 0 | -2.7622314598411322,0,-1.059390797308879e-08 | 0,0.12457627329584101,3.8241540462815958e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.882Z | Complex Chain | 5333608.4716825569,2184676.8851517248,361.71336016160473 | 0 | 0 | 0 | -2.7622314598411322,0,-1.059390797308879e-08 | 0,0.12457627329584101,3.8247224804702039e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.891Z | Complex Chain | 5333608.4716825578,2184676.8851517243,361.61810997110433 | 0 | 0 | 0 | -2.7622314598411322,0,-1.059390797308879e-08 | 0,0.12457627329584101,3.8247224804702039e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.901Z | Complex Chain | 5333605.7107326603,2184676.9693947257,361.41490955411484 | 0 | 0 | 0 | 0,-0.025421769823879004,0 | 2.766117375344038,0.037197120022028685,1.0961230145767331e-08
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.911Z | Complex Chain | 5333605.7107326612,2184676.9693947257,361.28790930011434 | 0 | 0 | 0 | 0,-0.025421769823879004,0 | 2.766117375344038,0.037197120022028685,1.0961286989186192e-08
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.921Z | Complex Chain | 5333605.7107275547,2184676.9693946494,361.16090904611377 | 0 | 0 | 0 | 0,-0.025421769823879004,0 | 2.7661173744127154,0.037197120022028685,1.0961286989186192e-08
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.931Z | Complex Chain | 5333606.4465203648,2184676.9803701076,360.97271515996698 | 0 | 0 | 0 | 0,-0.036397221498191357,0 | 2.0303245643153787,0.026221668347716331,8.0165705185208935e-09
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.943Z | Complex Chain | 5333606.4465203667,2184676.9803701076,360.6522850278792 | 0 | 0 | 0 | 0,-0.036397221498191357,0 | 2.0303245643153787,0.026221668347716331,8.0165136751020327e-09
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.952Z | Line | 5333608.2031360483,2184677.0065739066,361.91273601251078 | 0 | 0 | 0 | 0,0,0 | 0.0012815622612833977,1.9117258489131927e-05,5.1159076974727213e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.966Z | Line | 5333608.2044176105,2184677.0065930239,361.91273601251589 | 0 | 0 | 0 | -6.1728060245513916e-06,0,0 | 0,0.00041378848254680634,6.2527760746888816e-13
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.977Z | Line String | 5333605.7186072543,2184676.9885353749,361.00292850553194 | 0 | 0 | 0 | 0,0,0 | 2.7128558522090316,0.040466306731104851,1.0856979315576609e-08
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.985Z | Line | 5333606.1790454555,2184676.9954035007,361.00292850737469 | 0 | 0 | 0 | 0,0,0 | 0,0,0.053780962995517712
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:55.994Z | Line | 5333606.6361955162,2184677.002222578,361.00292850920431 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,0 | 0,0,0.036303225580581966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.003Z | Line | 5333607.3028732613,2184677.0121670747,361.00292851187231 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,0.037554252551672107
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.013Z | Line | 5333608.0076456377,2184677.0226798104,361.00292851469283 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,0.037554252551672107
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.022Z | Line | 5333608.4314631065,2184677.0290016821,361.00292851638892 | 0 | 0 | 0 | 0,0,0 | 0,0,0.073869316551167685
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.033Z | Complex Chain | 5333606.1817464046,2184676.8144477,360.90767847021033 | 0 | 0 | 0 | -0.0054018989058389122,-1.0338462100301093e-09,-0.055262693693748588 | 0,0.36191163025542633,0.095250076809526504
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.043Z | Complex Chain | 5333606.1763456557,2184677.1763593499,360.58724836384658 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163304708973,-0.055262696017052804 | 0.005401899991536418,0,0.095250074340475846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.051Z | Complex Chain | 5333606.6388964653,2184676.8212667773,360.90767847203995 | 0 | 0 | 0 | -0.0054018989058389122,-5.6818492966126399e-10,-0.055262693693805431 | 0,0.36191163025542633,0.095250076809412818
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.061Z | Complex Chain | 5333606.6334957164,2184677.1831784272,360.58724836567609 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163258142844,-0.055262696017052804 | 0.0054018999915364189,0,0.095250074340532689
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.069Z | Complex Chain | 5333607.3055742094,2184676.8312112736,360.90767847470801 | 0 | 0 | 0 | -0.0054018979745163375,-1.0338462239078972e-09,-0.055262693693748588 | 0,0.36191163025542633,0.095250076809469661
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.079Z | Complex Chain | 5333607.3001734614,2184677.1931229234,360.58724836834421 | 0 | 0 | 0 | -1.3401840806819693e-09,-0.36191163304708973,-0.055262696017052804 | 0.0054018990602138443,0,0.095250074340475846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.087Z | Complex Chain | 5333608.4341640547,2184676.84804588,360.90767847922473 | 0 | 0 | 0 | -0.0054018979745163375,-5.681849435390518e-10,-0.055262693693748588 | 2.5448644732327386e-10,0.36191163025542633,0.095250076809412818
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.094Z | Complex Chain | 5333608.4287633067,2184677.2099575298,360.58724837286093 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163258142844,-0.055262696017052804 | 0.0054018990602138443,0,0.095250074340475846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.102Z | Complex Chain | 5333608.0103465868,2184676.8417240083,360.90767847752858 | 0 | 0 | 0 | -0.0054018989058389122,-1.033846237785685e-09,-0.055262693693805431 | 0,0.36191162978976504,0.095250076809469661
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.112Z | Complex Chain | 5333608.0049458379,2184677.2036356581,360.58724837116478 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.36191163304708973,-0.055262696017052804 | 0.0054018999915364189,0,0.095250074340475846
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.120Z | Line | 5333605.7085311655,2184677.0838893256,361.41756522860538 | 0 | 0 | 0 | 0,-0.16062615718692541,0 | 1.8982198908925056,0,7.2848820309445728e-09
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.130Z | Line | 5333605.7075809967,2184677.1475213375,361.09541033978917 | 0 | 0 | 0 | 0,-0.16062615672126412,0 | 1.8982198899611831,0,7.2848820309445728e-09
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.144Z | Extended Element | 5333608.5311967358,2184676.8336477149,361.03461387661054 | -179.145 | -2.24683e-07 | 90 | -1.3484160454879657e-09,-4.546363285840016e-14,-7.4558534346458316e-10 | 2.8702074749038262,0.96449685686095799,0.44452842015526745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.154Z | Extended Element | 5333608.5347309206,2184676.7955956426,359.10097323298504 | -179.145 | -0.0870405 | 90 | -0.0071970898678448414,-1.0933393623568932e-05,-0.031818823622548148 | 2.1437363758599135,1.9368950494572839,0.51441882227222591
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.176Z | Extended Element | 10667163.413247569,4369379.1548232157,-808.59017235542387 | 180 | -0.000327487 | 0.021939 | 5333548.8066192446,2184691.6537052095,363.5576996470129 | 5333551.6831396436,2184692.1413379405,364.52236667651022
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.194Z | Line | 5333549.4772234326,2184690.2006051866,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.203Z | Line | 5333549.9543611826,2184690.0838845856,360.61601379941141 | 0 | 0 | 0 | 0,0,-0.017542575285858675 | 0,8.8475644588470459e-09,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.214Z | Line | 5333549.9543611826,2184690.0838845852,360.93644393149924 | 0 | 0 | 0 | -9.3132257461547852e-10,0,-0.017542599524460911 | 0,8.8475644588470459e-09,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.224Z | Extended Element | 5333553.1541442517,2184686.9404796837,359.04882696476295 | -179.145 | -0.0870403 | 90 | -0.0071970895861239725,-1.0933394532619545e-05,-0.031818823379686473 | 2.1437363761416344,1.9368950494563739,0.51441882251508741
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.234Z | Line | 5333607.8882334922,2184676.8780375919,360.98057252713124 | 0 | 0 | 0 | 0,0,-1.8288036576075228 | 7.4505805969238281e-09,2.7939677238464355e-09,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.261Z | Extended Element | 5333608.1303914478,2184676.9896120117,360.18580997867281 | -67.7257 | 1.06461e-08 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.288Z | Extended Element | 5333608.131906813,2184676.8880221313,360.18580997851296 | -67.7257 | 1.06461e-08 | 90 | -0.0079375001689504007,-7.2600076550622019e-13,-0.0079374996896115092 | 0.0079374999920366254,1.7442250443987126,0.0079375003118404858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.312Z | Extended Element | 5333608.2448527971,2184676.9796629939,360.18580997911215 | -67.7257 | 1.07686e-08 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.338Z | Extended Element | 5333608.2461943282,2184676.8897269014,360.18580997897033 | -67.7257 | 2.54302e-08 | 90 | -0.0079374999549497189,-7.302873931808936e-13,-0.0079374996808504704 | 0.0079375002051620073,1.7243812448037525,0.0079375003206101045
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.364Z | Extended Element | 5333608.3595590275,2184676.9532971391,360.18580997949869 | -67.7257 | -2.11625e-08 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.389Z | Extended Element | 5333608.3604818424,2184676.8914316711,360.1858099794058 | -67.7257 | -4.81455e-08 | 90 | -0.0079375009042550321,-8.9998048830108994e-12,-0.0079374997296075851 | 0.0079375002095479538,1.7045374451692137,0.0079375012255443137
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.417Z | Extended Element | 5333608.448774985,2184676.932790366,360.18580997982468 | -67.7257 | 1.36995e-08 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.443Z | Extended Element | 5333608.4493721342,2184676.8927576025,360.18580998050527 | -67.7257 | 1.36995e-08 | 90 | -0.0079375000907182438,-3.180032625783768e-13,-0.007937500850699936 | 0.0079374999897989396,1.6891033782071561,0.0079374991500497562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.469Z | Extended Element | 5333605.7526676804,2184677.1588283824,360.4504126973784 | 0.854621 | 3.46726e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.496Z | Extended Element | 5333605.9815825094,2184677.1394577576,360.45041269764693 | 0.854621 | 3.46726e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.521Z | Extended Element | 5333606.2104973393,2184677.1200871286,360.45041269925844 | 0.854622 | 4.32766e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.546Z | Extended Element | 5333606.4394121701,2184677.1007165015,360.45041269967766 | 0.854621 | 4.32766e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.568Z | Extended Element | 5333606.6683269963,2184677.0813458739,360.45041270061347 | 0.854623 | 5.18806e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.589Z | Extended Element | 5333606.8972418308,2184677.0619752477,360.45041270235981 | 0.854621 | 4.32766e-07 | 90 | -0.011505940775614747,-4.3329859226381003e-19,-0.0092402452382163974 | 0.011505938417301584,0.96571897085130165,0.17479125099282075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.618Z | Extended Element | 5333608.0064843297,2184676.8877389431,361.94178374648192 | 0.855133 | 2.02049e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.644Z | Extended Element | 5333607.8541009743,2184676.8854659167,361.9417837455257 | 0.855135 | 2.66705e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.669Z | Extended Element | 5333607.7017176198,2184676.8831928908,361.94178374516588 | 0.855134 | 2.66713e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.696Z | Extended Element | 5333607.5493342644,2184676.8809198644,361.94178374505725 | 0.855135 | 2.02032e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.721Z | Extended Element | 5333607.3207592368,2184676.877510326,361.9417837439068 | 0.855134 | 2.67207e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.746Z | Extended Element | 5333607.0921842083,2184676.8741007871,361.94178374241636 | 0.855134 | 2.68194e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.779Z | Extended Element | 5333606.8636091799,2184676.8706912491,361.94178374216187 | 0.855134 | 2.677e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.806Z | Extended Element | 5333606.6350341486,2184676.8672817103,361.94178374072487 | 0.855133 | 2.67708e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.833Z | Extended Element | 5333606.4064591201,2184676.8638721718,361.94178374035016 | 0.855134 | 2.677e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.860Z | Extended Element | 5333606.1778840926,2184676.8604626334,361.94178373897677 | 0.855135 | 2.66705e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.889Z | Extended Element | 5333605.9493090631,2184676.8570530931,361.94178373789782 | 0.855135 | 2.01539e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.923Z | Extended Element | 5333605.7207340337,2184676.8536435547,361.94178373705802 | 0.855135 | 2.67692e-07 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.947Z | Extended Element | 5333608.1139959916,2184677.0242951503,361.93279110775251 | -179.145 | -6.44025e-07 | -89.9985 | -0.013383665148291524,-2.0613436121344486e-07,-0.013392900089961343 | 0.013383665484346984,0.43724793801004758,0.14989939992524939
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:56.974Z | Extended Element | 5333608.2282834994,2184677.0259999195,361.91294511675068 | -179.145 | -1.16299e-07 | -89.9983 | -0.013383673838384916,-2.3365829091511947e-07,-0.013393766319802344 | 0.013383672722568426,0.42454708563157617,0.14989854031566802
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.006Z | Extended Element | 5333608.3425710108,2184677.0277046892,361.89310123286975 | -179.145 | -1.63989e-07 | -89.9983 | -0.013383671999201482,-2.4193799773950873e-07,-0.013393736390429629 | 0.01338367305430911,0.4118471145939836,0.149898569833153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.033Z | Extended Element | 5333608.4314613016,2184677.0290306206,361.87766707539686 | -179.145 | -4.89642e-07 | -89.9982 | -0.013383672314236547,-2.5083639676360559e-07,-0.013393705419718058 | 0.013383672646049663,0.39914714553692082,0.14989860043402853
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.060Z | Extended Element | 5333605.7094510971,2184676.9693756099,361.93561059551178 | -89.1454 | 180 | -1.10993e-07 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.086Z | Extended Element | 5333605.7109190878,2184676.870961627,361.93561059535682 | -89.1454 | -180 | -3.22621e-07 | -0.0092071357171118785,1.6463745592782527e-11,-0.0092071394725775878 | 0.0092071349318318379,2.7639737037872001,0.07733635312607634
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.115Z | Extended Element | 5333605.7094510971,2184676.9693756104,361.80861034151121 | 42.9456 | -90 | 132.091 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.142Z | Extended Element | 5333605.7094510971,2184676.9693756099,361.71336015101093 | 42.9493 | -90 | 132.095 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.171Z | Extended Element | 5333605.709451098,2184676.9693756099,361.61810996051054 | 42.9493 | -90 | 132.095 | -0.01249725444474043,1.6021112814371848e-10,-0.012497255377699157 | 0.012497254331349456,2.7731652787965877,0.12541275084542841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.201Z | Extended Element | 5333605.7107326621,2184676.9693947267,361.4149095541149 | 22.331 | -90 | 111.476 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.229Z | Extended Element | 5333605.7107326621,2184676.9693947262,361.28790930011434 | 22.3428 | -90 | 111.488 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.257Z | Extended Element | 5333605.7107275557,2184676.9693946494,361.16090904611377 | 22.3547 | -90 | 111.5 | -0.0093330072027218765,-9.4855593385647866e-11,-0.0093330020800201849 | 0.0093330072026074525,2.7673238208586213,0.074383534343518756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.288Z | Extended Element | 5333605.7075809976,2184677.1475213375,361.09541033978911 | -94.8384 | -90.0079 | -0.00159386 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.314Z | Extended Element | 5333605.70865364,2184677.0756788854,361.45987457592378 | -94.8384 | -90.0079 | -0.00159224 | -0.0079374999999434013,6.7382325770578076e-10,-0.0079374999089222055 | 0.007937500000115295,1.9050038096490431,0.0079375000910783238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.341Z | Extended Element | 5333605.7109190887,2184676.8709616275,361.80861034135626 | -89.1467 | -90.0098 | -0.0013072 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.370Z | Extended Element | 5333605.7109190878,2184676.8709616275,361.71336015085598 | -89.1467 | -90.0098 | -0.00130754 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.396Z | Extended Element | 5333605.7109190915,2184676.8709616279,361.61810996035558 | -89.1467 | -90.0098 | -0.00130789 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.423Z | Extended Element | 5333605.7109190905,2184676.8709616284,361.41490955395471 | -89.1467 | -90.0098 | -0.00130862 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.450Z | Extended Element | 5333605.7109190924,2184676.8709616284,361.28790929995432 | -89.1467 | -90.0098 | -0.00130908 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.475Z | Extended Element | 5333605.7109190905,2184676.8709616284,361.16090904595382 | -89.1467 | -90.0098 | -0.00130955 | -0.0079375000000000053,5.229050764999807e-11,-0.0079375001961827108 | 0.0079375000000000053,2.7686055384205175,0.0079374998038173016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.499Z | Extended Element | -62793.097557576242,4209313.8074365789,-0.021477599499668147 | 1.70918 | 0 | 180 | 5333548.834260189,2184689.8005161546,-361.94696446543145 | 5333551.7107825289,2184690.2878327128,-360.98246760799026
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.513Z | Extended Element | 5333544.1668013344,2184675.8735564901,360.96099000884061 | 0.854011 | 4.5952e-09 | 90 | -1.7778749583641229e-09,1.1379786002407855e-14,-0.44452842049203461 | 2.8702074744743675,0.96449685686101483,4.0881817375826301e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.522Z | Complex Chain | 5333610.3920285143,2184690.9679382071,361.92634131992457 | 0 | 0 | 0 | -0.001990162767469883,0,-0.85407499989568336 | 9.3132257461547852e-10,0.13333514857630735,2.0241941456333734e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.533Z | Complex Chain | 5333610.6206035437,2184690.9713477455,361.92634131988632 | 0 | 0 | 0 | -0.0019901628293044551,-1.2632019041891596e-10,-0.85407499990432356 | 0,0.13333514844998717,1.879243427538313e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.541Z | Complex Chain | 5333610.8491785731,2184690.9747572849,361.92634132008698 | 0 | 0 | 0 | -0.0019901636987924576,-5.9198398960624843e-10,-0.85407499984821911 | 0,0.13333514798432589,2.9689317671000026e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.552Z | Complex Chain | 5333611.0777536007,2184690.9781668237,361.92634132058248 | 0 | 0 | 0 | -0.001990162767469883,-1.2632019041891596e-10,-0.85407499990062874 | 9.3132257461547852e-10,0.13333514811064606,1.9514345694915392e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.562Z | Complex Chain | 5333611.3063286301,2184690.9815763622,361.9263413200789 | 0 | 0 | 0 | -0.001990162767469883,0,-0.85407499989949187 | 6.1847624894736941e-11,0.13333514891564846,1.9520030036801472e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.571Z | Complex Chain | 5333611.5349036604,2184690.9849859015,361.92634132063785 | 0 | 0 | 0 | -0.0019901618979949178,0,-0.85407499988323465 | 6.1847609499066092e-11,0.13333514891564846,2.2424728740588762e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.583Z | Complex Chain | 5333611.7634786889,2184690.9883954395,361.92634132001427 | 0 | 0 | 0 | -0.0019901618979818805,0,-0.85407499990898472 | 9.3132257461547852e-10,0.13333514857630735,1.879243427538313e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.591Z | Complex Chain | 5333611.9920537174,2184690.9918049779,361.92634132062642 | 0 | 0 | 0 | -0.001990162767469883,0,-0.85407499990114033 | 6.1847624894736941e-11,0.13333514857630713,2.0975221559638157e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.600Z | Complex Chain | 5333612.2206287459,2184690.9952145168,361.92634132089898 | 0 | 0 | 0 | -0.0019901628293175081,-1.2631994061873542e-10,-0.85407499990375513 | 0,0.13333514844998717,1.9508661353029311e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.609Z | Complex Chain | 5333612.3730121003,2184690.9974875427,361.92634132042207 | 0 | 0 | 0 | -0.0019901636987924576,-1.0576423209451846e-09,-0.85407499989568336 | 6.1860669581595418e-11,0.13333514844998717,2.0969537217752077e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.619Z | Complex Chain | 5333612.5253954539,2184690.9997605681,361.92634132019657 | 0 | 0 | 0 | -0.0019901618361473083,-1.2632019041891596e-10,-0.85407499989761604 | 9.9315714701710134e-10,0.13333514891564846,1.9514345694915392e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.630Z | Complex Chain | 5333612.6777788093,2184691.0020335945,361.9263413205673 | 0 | 0 | 0 | -0.0019901628293175081,0,-0.85407499990028768 | 0,0.13333514891564846,1.9514345694915392e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.639Z | Complex Chain | 5333612.7873280207,2184691.0020800084,361.91734868118766 | 0 | 0 | 0 | -0.0020375475287437439,0,-0.42386249988983976 | 1.4825089842806366e-09,0.13650979519725107,2.2919266484677792e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.649Z | Complex Chain | 5333612.9016155368,2184691.0037847771,361.89750488069291 | 0 | 0 | 0 | -0.0020375578620216864,0,-0.41116359551934428 | 0,0.13650979633206112,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.665Z | Complex Chain | 5333613.015903051,2184691.0054895473,361.87766108078659 | 0 | 0 | 0 | -0.0020375589895083777,0,-0.39846363792806394 | 0,0.13650979539031358,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.674Z | Complex Chain | 5333613.10479334,2184691.0068154777,361.86222701371537 | 0 | 0 | 0 | -0.0020375568419694901,0,-0.38576368320498872 | 2.3746115839721332e-09,0.13650979520753026,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.685Z | Complex Chain | 5333610.3822135692,2184690.9852562794,361.92016817825993 | 0 | 0 | 0 | 0,0,-0.069515841665861444 | 2.7623086608946323,0.041205356363207102,1.8940227164421231e-10
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.693Z | Complex Chain | 5333610.3807455776,2184691.0836702622,361.92016817841471 | 0 | 0 | 0 | 0,0,-0.069515841665861444 | 2.7623086608946323,0.041205356363207102,1.8945911506307311e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.703Z | Line | 5333612.2771695713,2184691.0961503116,361.44443215898548 | 0 | 0 | 0 | -1.892584253102541,-0.21717356657609344,-3.1832314562052488e-12 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.712Z | Line | 5333612.2782422174,2184691.0243078582,361.07996792273786 | 0 | 0 | 0 | -1.8925842540338635,-0.21717356517910957,-3.1832314562052488e-12 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.721Z | Complex Chain | 5333610.4110764284,2184690.9682223382,360.1777285264929 | 0 | 0 | 0 | -0.0019901652086208943,0,0 | 0,0.13333515157976661,1.3012192101712061
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.731Z | Complex Chain | 5333610.6396514578,2184690.9716318771,360.17772852652956 | 0 | 0 | 0 | -0.0019901661399434689,0,0 | 0,0.13333515157976661,1.3012192101531868
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.738Z | Complex Chain | 5333610.8682264863,2184690.9750414155,360.17772852656623 | 0 | 0 | 0 | -0.001990167070912781,0,0 | 0,0.13333514971712657,1.3012192102329947
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.748Z | Complex Chain | 5333611.0968015157,2184690.9784509544,360.17772852660289 | 0 | 0 | 0 | -0.0019901642772983267,0,0 | 5.0354031534693977e-10,0.13333515157976661,1.3012192101651239
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.756Z | Complex Chain | 5333611.325376546,2184690.9818604928,360.17772852663961 | 0 | 0 | 0 | -0.0019901661395901795,0,0 | 0,0.13333515077829361,1.3012192102376559
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.767Z | Complex Chain | 5333611.5539515745,2184690.9852700317,360.17772852667622 | 0 | 0 | 0 | -0.0019901661399434755,0,0 | 0,0.13333515204542784,1.301219210162168
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.777Z | Complex Chain | 5333611.7825266058,2184690.9886795706,360.17772852671288 | 0 | 0 | 0 | -0.0019901652086209004,0,0 | 0,0.13333515064844398,1.3012192101587574
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.784Z | Complex Chain | 5333612.0111016352,2184690.992089109,360.17772852674955 | 0 | 0 | 0 | -0.0019901661399434746,0,0 | 0,0.1333351515797665,1.3012192101594964
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.792Z | Complex Chain | 5333612.2396766637,2184690.9954986479,360.17772852678621 | 0 | 0 | 0 | -0.0019901661399434746,0,0 | 0,0.13333515111410521,1.3012192101634186
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.802Z | Complex Chain | 5333612.3920600181,2184690.9977716738,360.17772852681065 | 0 | 0 | 0 | -0.0019901661399434742,0,0 | 0,0.13333515064844392,1.3012192101625659
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.811Z | Complex Chain | 5333612.5444433736,2184691.0000446993,360.1777285268351 | 0 | 0 | 0 | -0.0019901652086208995,0,0 | 0,0.13333515204542778,1.3012192101688187
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.819Z | Complex Chain | 5333612.6968267271,2184691.0023177252,360.1777285268596 | 0 | 0 | 0 | -0.0019901642772983249,0,0 | 5.0354031317853543e-10,0.13333515204542776,1.3012192101714903
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.830Z | Complex Chain | 5333610.4444498708,2184690.9640166415,361.9284960596018 | 0 | 0 | 0 | 0,-0.1534436019735855,-0.85159357443305039 | 0.0022889434007057272,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.838Z | Complex Chain | 5333610.6726850672,2184690.9902066137,361.92849605945219 | 0 | 0 | 0 | 0,-0.1534436019735855,-0.85159357443305039 | 0.0022889443320283018,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.849Z | Complex Chain | 5333610.9009202644,2184691.0163965886,361.92849606021542 | 0 | 0 | 0 | 0,-0.15344360243924679,-0.85159357443305039 | 0.0022889443320283018,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.857Z | Complex Chain | 5333610.4310618304,2184690.7971768496,360.4349702797378 | 0 | 0 | 0 | -0.002436238224863393,0,0 | 0,0.16331763258601867,0.95426667055775449
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.864Z | Complex Chain | 5333610.6592970286,2184690.8233668217,360.43497027958824 | 0 | 0 | 0 | -0.0024362391561859676,0,0 | 0,0.16331763305167996,0.95426667055775449
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.872Z | Complex Chain | 5333610.8875322267,2184690.849556799,360.43497028078167 | 0 | 0 | 0 | -0.0024362391561859676,0,0 | 0,0.16331763305167996,0.95426667055769765
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.883Z | Complex Chain | 5333611.1157674249,2184690.875746774,360.43497028078281 | 0 | 0 | 0 | -0.0024362400875085422,0,0 | 0,0.16331763258601867,0.95426667055775449
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.891Z | Complex Chain | 5333611.3440026203,2184690.901936749,360.43497028130042 | 0 | 0 | 0 | -0.0024362391561859676,0,0 | 0,0.16331763258601867,0.95426667055775449
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.900Z | Complex Chain | 5333611.5722378213,2184690.928126723,360.43497028262874 | 0 | 0 | 0 | -0.002436238224863393,0,0 | 0,0.16331763258601867,0.95426667055769765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.914Z | Extended Element | 5333613.1986553539,2184691.2050892636,361.0191714592043 | -179.146 | -2.10555e-07 | 90 | -1.7083221504066159e-09,4.1244785364824565e-14,-0.44452842127324155 | 2.8702074745439194,0.96449685686104492,-3.7238898076275007e-10
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.939Z | Extended Element | 5333613.1027557841,2184691.1433252734,361.86222464784169 | -179.145 | -2.10614e-07 | -89.9982 | -0.013383672314236547,-2.5083639676360559e-07,-0.013393705419718058 | 0.013383672646049663,0.39914714553692082,0.14989860043402853
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.966Z | Extended Element | 5333613.0138654923,2184691.141999342,361.87765880565593 | -179.145 | 1.08204e-07 | -89.9983 | -0.013383671999201482,-2.4193799773950873e-07,-0.013393736390429629 | 0.01338367305430911,0.4118471145939836,0.149898569833153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:57.991Z | Extended Element | 5333612.8995779809,2184691.1402945714,361.89750268997585 | -179.145 | -1.17314e-07 | -89.9983 | -0.013383673838384916,-2.3365829091511947e-07,-0.013393766319802344 | 0.013383672722568426,0.42454708563157617,0.14989854031566802
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.018Z | Extended Element | 5333612.7852904731,2184691.1385898031,361.91734868141691 | -179.145 | -3.87193e-07 | -89.9985 | -0.013383665148291524,-2.0613436121344486e-07,-0.013392900089961343 | 0.013383665484346984,0.43724793801004758,0.14989939992524939
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.041Z | Extended Element | 5333612.6777788112,2184691.002033595,361.92634132056736 | 0.855134 | -6.25723e-08 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.064Z | Extended Element | 5333612.5253954539,2184690.9997605681,361.92634132019663 | 0.855134 | 2.59357e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.091Z | Extended Element | 5333612.3730121013,2184690.9974875432,361.92634132042207 | 0.855133 | 2.60188e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.116Z | Extended Element | 5333612.2206287468,2184690.9952145168,361.92634132089898 | 0.855134 | -6.25723e-08 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.142Z | Extended Element | 5333611.9920537155,2184690.9918049783,361.92634132062642 | 0.855134 | 3.08722e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.167Z | Extended Element | 5333611.7634786898,2184690.9883954395,361.92634132001427 | 0.855133 | 4.08297e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.192Z | Extended Element | 5333611.5349036613,2184690.984985902,361.92634132063785 | 0.855134 | 3.58092e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:58.219Z | Extended Element | 5333611.306328631,2184690.9815763631,361.92634132007896 | 0.855134 | 3.58086e-09 | -90.0006 | -0.013704519369524047,-1.4367581637876872e-06,-0.013696596562958843 | 0.01370451874991363,0.86774787113237684,0.14706243225426902
