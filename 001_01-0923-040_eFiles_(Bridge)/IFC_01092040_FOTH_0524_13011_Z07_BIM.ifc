Properties of the parts of a building model (IFC4X3_ADD2), part 30 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.498Z | Extended Element | 5333609.0248425677,2184683.8496459224,360.76160916137837 | 70.8546 | -0.0000232809 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.526Z | Extended Element | 5333610.9607747979,2184691.159005018,360.58712140953543 | -179.145 | -86.8547 | -0.00000996028 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.553Z | Extended Element | 5333610.9607744077,2184691.1590050156,360.26327076178791 | -179.145 | -86.8547 | -0.00000967058 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.581Z | Extended Element | 5333610.9607740128,2184691.1590050128,359.93783261096479 | -179.145 | -86.8547 | -0.00000995113 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.608Z | Extended Element | 5333611.3835017039,2184691.1653129738,360.60734811031818 | -179.145 | -86.8547 | -0.00000967509 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.630Z | Extended Element | 5333611.3835014123,2184691.1653106143,360.33675448971991 | -179.145 | -86.8547 | -0.00000995156 | -0.009578162723497638,1.2527978700908409e-10,-0.009578163515418809 | 0.021343075162891911,7.4982849931431437,2.5816054649646532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.656Z | Extended Element | 5333606.2929375237,2184676.8129617348,360.60389121377472 | 0.854594 | -87.2474 | 0.00000611256 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.683Z | Extended Element | 5333606.2929371344,2184676.8129617311,360.28004056605704 | 0.854594 | -87.2474 | 0.00000574265 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.711Z | Extended Element | 5333606.2929367432,2184676.8129617274,359.95460241514445 | 0.854594 | -87.2474 | 0.00000582564 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.738Z | Extended Element | 5333606.7156611066,2184676.8192672851,360.35261122649911 | 0.854594 | -87.2474 | 0.00000573638 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.768Z | Extended Element | 5333606.7156614335,2184676.8192672883,360.62320484712723 | 0.854594 | -87.2474 | 0.00000575648 | -0.0095778851199443821,5.7513683145093907e-11,-0.0095778830079487429 | 0.02135765951958267,7.498547514695141,2.5808837788106027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.797Z | Extended Element | 5333606.5373662254,2184680.1552016772,360.64206521155489 | 160.578 | -90.0048 | -0.276749 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.824Z | Extended Element | 5333606.5373658361,2184680.1552016749,360.31503955750401 | 160.578 | -90.0048 | -0.277 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.850Z | Extended Element | 5333606.4332357869,2184679.8552622278,359.98801403196728 | 160.577 | -90.0048 | -0.277251 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.879Z | Extended Element | 5333607.391951981,2184682.6167863761,360.68711418097672 | 160.578 | -90.0048 | -0.276715 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.906Z | Extended Element | 5333607.3919515861,2184682.6167863747,360.36008852692663 | 160.578 | -90.0048 | -0.276965 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.935Z | Extended Element | 5333607.2878215434,2184682.3168469272,360.03306300138729 | 160.577 | -90.0048 | -0.277216 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.964Z | Extended Element | 5333608.2465377003,2184685.0783710931,360.72272685374833 | 160.578 | -90.0048 | -0.276687 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.991Z | Extended Element | 5333608.2465373082,2184685.0783710908,360.3957011996975 | 160.578 | -90.0048 | -0.276937 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.021Z | Extended Element | 5333608.1424072636,2184684.7784316456,360.06867567415901 | 160.577 | -90.0048 | -0.277188 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.049Z | Extended Element | 5333609.1011234242,2184687.5399557222,360.67792294759107 | 160.578 | -90.0048 | -0.276722 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.079Z | Extended Element | 5333609.1011230303,2184687.5399557194,360.35089729353996 | 160.578 | -90.0048 | -0.276972 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.105Z | Extended Element | 5333608.9969929876,2184687.2400162732,360.02387176800147 | 160.577 | -90.0048 | -0.277223 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.131Z | Extended Element | 5333609.955709137,2184690.0015403479,360.62502929691738 | 160.578 | -90.0048 | -0.276763 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.159Z | Extended Element | 5333609.955708744,2184690.0015403451,360.29800364286621 | 160.578 | -90.0048 | -0.277013 | -0.0079375000000027705,2.3282787519137178e-10,-0.0079375004770271401 | 0.0079375000008176776,2.3368046748582301,0.0079374995229784043
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.186Z | Extended Element | 5333609.8515786994,2184689.701600899,359.97097811732692 | 160.577 | -90.0048 | -0.277264 | -0.0079375000030409183,-1.4116722533157762e-14,-0.0079374994414891514 | 0.0079375000000141208,1.7018034038543837,0.0079375005585390901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.214Z | Extended Element | 5333607.3021228136,2184690.5458124341,360.9147443535698 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.237Z | Extended Element | 5333607.2063235408,2184690.2698681476,360.92023416663795 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.261Z | Extended Element | 5333607.0813679677,2184689.9099408174,360.92803504958346 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.286Z | Extended Element | 5333606.9564124029,2184689.5500134858,360.93580726370135 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.313Z | Extended Element | 5333606.8314568242,2184689.1900861603,360.94339159154362 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.339Z | Extended Element | 5333606.7115270933,2184688.8446354801,360.95092595071515 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.366Z | Extended Element | 5333606.5915973624,2184688.4991848017,360.95834887129922 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.393Z | Extended Element | 5333606.4716676315,2184688.1537341238,360.9657717921998 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.419Z | Extended Element | 5333606.3517379044,2184687.808283445,360.97319471290302 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.444Z | Extended Element | 5333606.2267823368,2184687.4483561148,360.98092870281363 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.469Z | Extended Element | 5333606.10182676,2184687.0884287823,360.98870091676389 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.494Z | Extended Element | 5333605.9768711803,2184686.728501454,360.9963966829319 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.521Z | Extended Element | 5333605.856941455,2184686.383050777,361.00381960322153 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.549Z | Extended Element | 5333605.737011726,2184686.0376001028,361.01124252396568 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.576Z | Extended Element | 5333605.6170819979,2184685.6921494268,361.01866544457954 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.603Z | Extended Element | 5333605.4971522652,2184685.3466987507,361.02608836555532 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.631Z | Extended Element | 5333605.3721966986,2184684.9867714206,361.03382235547645 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.661Z | Extended Element | 5333605.2472411236,2184684.6268440904,361.04092859140604 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.687Z | Extended Element | 5333605.1222855421,2184684.2669167612,361.04559182645164 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.713Z | Extended Element | 5333605.0023558084,2184683.9214660814,361.04721998819213 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.740Z | Extended Element | 5333604.8824260673,2184683.5760154077,361.0460588670997 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.768Z | Extended Element | 5333604.7624963233,2184683.2305647298,361.04230405142806 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.795Z | Extended Element | 5333604.6425665794,2184682.8851140528,361.03628668454354 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.824Z | Extended Element | 5333604.5176109942,2184682.5251867208,361.02969972891947 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.854Z | Extended Element | 5333604.3926553959,2184682.1652593939,361.02309132822484 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.881Z | Extended Element | 5333604.2676998051,2184681.8053320632,361.01652581923247 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.910Z | Extended Element | 5333604.1477700612,2184681.4598813867,361.01020379795125 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.936Z | Extended Element | 5333604.0278403154,2184681.1144307074,361.00388177727029 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.968Z | Extended Element | 5333603.9079105677,2184680.7689800323,360.99755975652602 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:32.996Z | Extended Element | 5333603.7879808228,2184680.4235293549,360.99123773540242 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.024Z | Extended Element | 5333603.6630252358,2184680.0636020233,360.9846507802755 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.052Z | Extended Element | 5333603.538069644,2184679.7036746922,360.97804237796947 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.080Z | Extended Element | 5333603.4131140504,2184679.3437473639,360.97147686974927 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.108Z | Extended Element | 5333603.2931843083,2184678.9982966864,360.96515484903375 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.135Z | Extended Element | 5333603.1732545579,2184678.6528460109,360.95883282802879 | -89.1454 | 180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.160Z | Extended Element | 5333603.053324813,2184678.3073953339,360.95251080695829 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.186Z | Extended Element | 5333602.9333950682,2184677.9619446588,360.94618879376151 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.215Z | Extended Element | 5333602.8084394764,2184677.6020173277,360.93960183228836 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.245Z | Extended Element | 5333602.6885587675,2184677.2567047896,360.93376183516034 | -89.1454 | -180 | 0.25136 | -0.015058211855926505,-1.6238082346247236e-07,-0.01500933947380239 | 0.015058211641885916,3.6619308582903516,0.97788300495725422
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.254Z | Complex Chain | 5333560.8233089261,2184676.6189554469,360.91951854349418 | 0 | 0 | 0 | -0.14440275564310878,-0.0021539745847963931,-1.0002649848894107 | 0.39969061895726077,0.0059619998554968452,0.00047540309351327276
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.264Z | Complex Chain | 5333560.6797553515,2184676.6333823674,360.076370902284 | 0 | 0 | 0 | 0,0,-0.15711012494352289 | 0.54302040416460795,0.0080999713265681381,0.00071938003429750097
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.272Z | Complex Chain | 5333565.2002597032,2184689.9921761169,360.93474651064531 | 0 | 0 | 0 | -0.14440275564310878,-0.0021539750504576804,-1.0002649848893539 | 0.39969061895726077,0.0059619998554968452,0.00047540309357011618
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.282Z | Complex Chain | 5333565.0572018269,2184689.973371563,360.09159576127837 | 0 | 0 | 0 | 0,0,-0.15711012494352289 | 0.54302040416460795,0.0080999713265681381,0.00071938003429750097
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.292Z | Complex Chain | 5333591.9095374458,2184677.0826426507,360.96113040330903 | 0 | 0 | 0 | -0.14440275564310878,-0.0021539745847963931,-1.0002649848893539 | 0.39969061895726077,0.0059619998554968452,0.00047540309357011618
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.302Z | Complex Chain | 5333591.7659590458,2184677.0971717006,360.1179756192733 | 0 | 0 | 0 | 0,0,-0.15711012494357973 | 0.54302040416460795,0.0080999713265681381,0.00071938003429750097
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.313Z | Complex Chain | 5333560.6356384661,2184676.9956115368,360.52909612444643 | 0 | 0 | 0 | 0,-0.39783145892856525,-6.4170535551966168e-10 | 0.6244123365519274,0.0092341662384569645,0.0008260060603220154
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.325Z | Complex Chain | 5333560.6360355159,2184676.9956174544,360.22429557365825 | 0 | 0 | 0 | 0,-0.39783145892856525,-6.4170535551966168e-10 | 0.6244123365519274,0.0092341662384569645,0.00082600606026517198
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.334Z | Complex Chain | 5333591.7227486782,2184677.4593005986,360.56984279191153 | 0 | 0 | 0 | 0,-0.39783145939422654,-6.4170535551966168e-10 | 0.6244123365519274,0.0092341657727956772,0.0008260060603220154
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.344Z | Complex Chain | 5333591.7227085317,2184677.4592999984,360.26504219001026 | 0 | 0 | 0 | 0,-0.39783145892856525,-6.4176219893852249e-10 | 0.6244123365519274,0.0092341662384569645,0.00082600606026517198
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.353Z | Complex Chain | 5333596.1100640371,2184690.0737866662,360.25922056695157 | 0 | 0 | 0 | -0.0053555042916310219,0,0 | 0.61905683577060699,0.4070656291072911,0.00082600669987817875
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.361Z | Complex Chain | 5333565.0236408291,2184689.6100861165,360.54434444035979 | 0 | 0 | 0 | -0.0053555042916310219,0,0 | 0.61905683577060699,0.4070656291072911,0.00082600669987817875
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.370Z | Complex Chain | 5333565.0242748028,2184689.6100955755,360.23954402101504 | 0 | 0 | 0 | -0.0053555042916310219,0,0 | 0.61905683577060699,0.4070656291072911,0.00082600669987817875
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.382Z | Complex Chain | 5333596.1098588435,2184690.0737836082,360.56402116575327 | 0 | 0 | 0 | -0.0053555042916310219,0,0 | 0.61905683577060699,0.4070656291072911,0.00082600669987817875
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.393Z | Complex Chain | 5333560.7401674427,2184677.2444322808,360.90119450530545 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374696234966,-1.000127269641041 | 0.66461043711751699,0.047492044106247813,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.403Z | Complex Chain | 5333561.5947531005,2184679.7060169918,360.95319747090463 | 0 | 0 | 0 | -0.13650380723679928,-0.23015374696234966,-1.000127269641041 | 0.66461043711751699,0.047492044106247813,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.414Z | Complex Chain | 5333562.4493387584,2184682.1676017037,361.00510456540297 | 0 | 0 | 0 | -0.1365038063377142,-0.23015374696234966,-1.000127269641041 | 0.66461043711751699,0.047492044571909101,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.426Z | Complex Chain | 5333563.3039244208,2184684.6291864156,361.00795455369035 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374742801095,-1.0001272696409842 | 0.66461043618619442,0.047492044106247813,1.8797128973346844e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.435Z | Complex Chain | 5333564.1585100787,2184687.0907711862,360.96174744126978 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374742801095,-1.000127269641041 | 0.66461043618619442,0.047492044106247813,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.443Z | Complex Chain | 5333560.6037276322,2184677.2918983176,360.05822992961924 | 0 | 0 | 0 | 0,-0.27744196634739637,-0.15716269395483096 | 0.80105024762451649,2.600724262276366e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.452Z | Complex Chain | 5333561.45831329,2184679.7534830286,360.11023289521842 | 0 | 0 | 0 | 0,-0.27744196634739637,-0.15716269395483096 | 0.80105024762451649,2.600724262276366e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.461Z | Complex Chain | 5333562.3128989479,2184682.2150677405,360.16213998971671 | 0 | 0 | 0 | 0,-0.27744196634739637,-0.15716269395483096 | 0.80105024762451649,2.6007708284050968e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.470Z | Complex Chain | 5333563.1674846094,2184684.676652452,360.16498997800414 | 0 | 0 | 0 | 0,-0.27744196588173509,-0.15716269395483096 | 0.80105024762451649,2.6007708284050968e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.480Z | Complex Chain | 5333564.0220702672,2184687.1382372226,360.11878286558357 | 0 | 0 | 0 | 0,-0.27744196588173509,-0.15716269395483096 | 0.80105024762451649,2.6007708284050968e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.489Z | Complex Chain | 5333591.8263714435,2184677.7081295587,360.9409721684255 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374742801095,-1.000127269641041 | 0.66461043618619442,0.047492044106247813,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.500Z | Complex Chain | 5333591.689931632,2184677.7555955951,360.09800759273929 | 0 | 0 | 0 | 0,-0.27744196588173509,-0.15716269395483096 | 0.80105024762451649,2.6007708284050968e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.512Z | Complex Chain | 5333592.6809571069,2184680.169714273,360.9890560891846 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374696234966,-1.0001272696409842 | 0.66461043618619442,0.047492044106247813,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.521Z | Complex Chain | 5333592.5445172954,2184680.2171803098,360.14609151349845 | 0 | 0 | 0 | 0,-0.27744196634739637,-0.15716269395483096 | 0.80105024762451649,2.600724262276366e-05,2.4057718519543414e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.532Z | Complex Chain | 5333593.5355427628,2184682.6312989839,361.03702780237342 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374696234966,-1.000127269641041 | 0.66461043708527945,0.047492044106247813,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.542Z | Complex Chain | 5333593.3991029523,2184682.6787650208,360.19406322668721 | 0 | 0 | 0 | 0,-0.27744196634739637,-0.15716269395483096 | 0.80105024759227894,2.600724262276366e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.550Z | Complex Chain | 5333594.3901284225,2184685.0928836954,361.03594354683554 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374696234966,-1.000127269641041 | 0.66461043711751699,0.047492044571909101,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.561Z | Complex Chain | 5333594.253688612,2184685.1403497322,360.19297897114933 | 0 | 0 | 0 | 0,-0.27744196634739637,-0.15716269395483096 | 0.80105024762451649,2.6007708284050968e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.571Z | Complex Chain | 5333595.2447140841,2184687.5544684078,360.98580332798599 | 0 | 0 | 0 | -0.13650380726903677,-0.23015374742801095,-1.000127269641041 | 0.66461043711751699,0.047492044106247813,1.8797128404912655e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.582Z | Complex Chain | 5333595.1082742736,2184687.6019344442,360.14283875229978 | 0 | 0 | 0 | 0,-0.27744196588173509,-0.15716269395483096 | 0.80105024762451649,2.6007708284050968e-05,2.4057719087977603e-06
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.593Z | Complex Chain | 5333561.9680439737,2184678.876914212,359.99460565041983 | 0 | 0 | 0 | 0,0,0 | 0.12493076734244823,1.1217723549343646,0.023427533981418946
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.602Z | Complex Chain | 5333561.4103732137,2184678.8693872816,359.99392479695308 | 0 | 0 | 0 | 0,0,0 | 0.12493062019348145,1.1217717174440622,0.023458070838501044
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.616Z | Complex Chain | 5333561.7504204372,2184680.3525301735,360.02509408338386 | 0 | 0 | 0 | -0.12493073008954525,-1.1217720257118344,-0.02343669529585668 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.626Z | Complex Chain | 5333562.8225144707,2184681.339288116,360.04648458255781 | 0 | 0 | 0 | 0,0,0 | 0.12493087165057659,1.121772809419781,0.015794181760611536
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.636Z | Complex Chain | 5333563.1626202781,2184682.8225034713,360.06278114421804 | 0 | 0 | 0 | -0.12495550606399775,-1.1218438297510147,-0.0086120605256496674 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.646Z | Complex Chain | 5333562.2649078928,2184681.3309709271,360.04586865359244 | 0 | 0 | 0 | 0,0,0 | 0.12493073008954525,1.1217723055742681,0.015825962982887631
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.656Z | Complex Chain | 5333562.6049987432,2184682.8141856957,360.06222169471687 | 0 | 0 | 0 | -0.12495549023151398,-1.1218435950577259,-0.0086496412293968206 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.667Z | Complex Chain | 5333563.4595245728,2184685.275713563,360.05029287627275 | 0 | 0 | 0 | -0.12493596039712429,-1.1217878703027964,0 | 0,0,0.013753582016079235
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.679Z | Complex Chain | 5333563.1193936719,2184683.7924832283,360.06352719583111 | 0 | 0 | 0 | 0,0,-0.0065768102248853211 | 0.12495549023151398,1.1218441138044,0.0004232829061834309
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.688Z | Complex Chain | 5333564.0170875341,2184685.2840301283,360.05078786023256 | 0 | 0 | 0 | -0.12493586353957653,-1.1217874116264284,0 | 0,0,0.013785383100923809
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.698Z | Complex Chain | 5333563.6769659445,2184683.8008002373,360.06407288981814 | 0 | 0 | 0 | 0,0,-0.0066086204002431259 | 0.12495550606399775,1.1218439918011427,0.00040437357858991163
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.708Z | Complex Chain | 5333564.8715706775,2184687.7456130376,360.0045039384604 | 0 | 0 | 0 | -0.12493576761335135,-1.1217872123233974,0 | 0,0,0.02141751105585854
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.718Z | Complex Chain | 5333564.5314636128,2184686.2624399248,360.03260567497443 | 0 | 0 | 0 | 0,0,-0.021396133880045909 | 0.12493586353957653,1.1217874889262021,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.726Z | Complex Chain | 5333564.3140450371,2184687.7372970278,360.00407919204395 | 0 | 0 | 0 | -0.12493586447089911,-1.1217878311872482,0 | 0,0,0.021385704030478792
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.736Z | Complex Chain | 5333563.9739178848,2184686.2541229757,360.03213022070719 | 0 | 0 | 0 | 0,0,-0.02136432556312684 | 0.12493595946580172,1.1217881059274077,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.747Z | Line String | 5333565.4995820438,2184689.8458113847,359.88865497044014 | 0 | 0 | 0 | 0,0,0 | 0.10158887691795826,0.0015153489075601101,0.076270529445764623
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.758Z | Complex Chain | 5333565.3859487725,2184688.7240234124,359.98625515549418 | 0 | 0 | 0 | 0,0,-0.021395075877990166 | 0.12493576854467392,1.1217871853150427,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.768Z | Complex Chain | 5333565.6124734161,2184689.0854090364,359.97954173728039 | 0 | 0 | 0 | -0.24220090918242931,0,-0.017683611971165192 | 0,0.91427230648696423,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.777Z | Complex Chain | 5333564.8284326559,2184688.7157069035,359.98584992823561 | 0 | 0 | 0 | 0,0,-0.02136327170791219 | 0.12493586540222168,1.121787813026458,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.785Z | Complex Chain | 5333565.3221718036,2184689.9863678403,359.9619928551374 | 0 | 0 | 0 | -0.27854932844638824,-0.9092749897390604,-0.00014674532559411091 | 0,0,0.017162554815570275
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.796Z | Complex Chain | 5333562.1945510199,2184679.2390764561,360.00232469401323 | 0 | 0 | 0 | -0.011383765377104282,0,0 | 0.11354710813611746,1.1217726613394916,0.023409899761929864
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.804Z | Complex Chain | 5333561.3400678234,2184676.7774932757,359.95038556824454 | 0 | 0 | 0 | -0.011385725811123848,0,0 | 0.11354489531368017,1.1217719758860767,0.02342275200385302
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.817Z | Complex Chain | 5333561.2270932766,2184677.5378943849,359.96606791705852 | 0 | 0 | 0 | -0.26716139726340771,-0.90926834521815181,-0.019158541796286954 | 0.011385733261704445,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.828Z | Complex Chain | 5333560.6693579918,2184677.5295749223,359.96534319010823 | 0 | 0 | 0 | 0,-0.91426662774756551,-0.01899360156005514 | 0.24225561134517193,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.838Z | Complex Chain | 5333560.7823506724,2184676.7691740878,359.94964796532236 | 0 | 0 | 0 | -0.01140386238694191,0,0 | 0.11352675780653954,1.1217717011459172,0.023435629419054749
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.858Z | Complex Chain | 5333591.8676420208,2184677.2328577517,359.99127518195343 | 0 | 0 | 0 | -0.011384680867195129,0,0 | 0.11354957148432732,1.1217823745682836,0.022046506629806117
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.868Z | Complex Chain | 5333591.7546684397,2184677.9932588758,360.00630025551754 | 0 | 0 | 0 | 0,-0.91427022218704224,-0.018038786759689174 | 0.24223667941987514,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.878Z | Complex Chain | 5333592.4250946138,2184677.2411729908,359.99120624302168 | 0 | 0 | 0 | -0.011362985707819462,0,0 | 0.11357126664370298,1.1217826958745718,0.022033616548526425
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.888Z | Complex Chain | 5333592.3121427288,2184678.0015744367,360.00621842698899 | 0 | 0 | 0 | -0.26718579046428204,-0.90927282581105828,-0.017807648935502129 | 0.011362982913851738,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.903Z | Extended Element | 5333592.564313815,2184677.2434367775,359.98167807748314 | -179.146 | 0 | 88.8727 | 1.4582959839692933e-10,-1.7120431808348435e-11,1.1106369154464122e-09 | 0.14876247878522258,0.019055010103446783,1.1234382650111958
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.915Z | Extended Element | 5333592.0314549031,2184677.9975758283,359.99669527182454 | 0.854428 | 0 | 91.1277 | -1.3914516205915106e-09,9.6029902779681819e-12,9.8288133091079549e-10 | 0.29024124184537214,0.019086087971111318,0.914887090528541
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.926Z | Extended Element | 5333592.0068712533,2184677.2351259324,359.98174103966903 | -179.144 | 0 | 88.8717 | 3.0269035333763128e-09,4.1616623341900194e-12,-5.6362825527764661e-10 | 0.14877258310765026,0.019060991201971696,1.1234350647810849
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.939Z | Extended Element | 5333591.7451416915,2184677.9933046978,359.99675012005838 | 0.856059 | 0 | 91.1287 | -2.9504008141456123e-09,9.5095858271276867e-12,8.9133678202878802e-10 | 0.2381270996362457,0.019076988718939557,0.9240821421405262
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.951Z | Extended Element | 5333561.479293637,2184676.7797714272,359.94086261818649 | -179.144 | 0 | 88.8113 | 2.0212351792281424e-09,7.5566254642556174e-12,-2.0554402631018441e-10 | 0.14876931103675164,0.01923346186911639,1.1234524004231841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.963Z | Extended Element | 5333560.9463910889,2184677.5339050647,359.95617511750504 | 0.856138 | 0 | 91.1891 | -5.4741433608285206e-11,7.3001223122037828e-12,1.4334089469949759e-09 | 0.29025545861907892,0.019419930458926867,0.91490259172791089
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.977Z | Extended Element | 5333560.9215848651,2184676.7714558411,359.94012501860362 | -179.142 | 0 | 88.8103 | 7.2244263349396931e-10,1.1649346418063367e-11,2.7295765644464696e-10 | 0.14877774788795506,0.019227478453608532,1.1234497809600328
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:33.992Z | Extended Element | 5333560.6598310973,2184677.5296301786,359.95582024467376 | 0.857502 | 0 | 91.1901 | 1.5716068056437751e-09,8.7646868929258659e-12,5.162110730322994e-10 | 0.23813453590595166,0.019353629488830702,0.92409240916255841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.004Z | Extended Element | 5333562.3337761853,2184679.2413545209,359.9928017497773 | -179.144 | 0 | 88.8096 | -6.4741448313476724e-10,1.4775741394301711e-11,-5.2889070917141357e-10 | 0.14876865954386889,0.019187611231047584,1.1234531054597512
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.017Z | Extended Element | 5333561.97710439,2184678.8739696336,359.98508254169036 | 160.855 | 0 | 88.8582 | 6.9849099453973708e-10,-2.6183447771055413e-12,1.581552666607422e-10 | 0.27911382941801399,0.020613834353947466,1.1004720562296317
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.031Z | Extended Element | 5333561.7414947776,2184680.3558629081,360.01400536293397 | -19.1454 | 0 | 91.1422 | 8.7562438456594814e-16,-2.9374610382992827e-11,-3.1560578256900962e-11 | 0.27913105740827737,0.020615924068753337,1.1004661007397272
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.045Z | Extended Element | 5333561.4194337828,2184678.8664431502,359.98440169765161 | 160.855 | 0 | 88.8554 | -3.4924627764889217e-10,-6.4268573102266302e-12,3.8984545833754181e-10 | 0.27913104207699291,0.020590065276246579,1.100466271884267
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.059Z | Extended Element | 5333563.1536280215,2184682.825644372,360.04580889948403 | -19.1454 | 0 | 90.0608 | 1.0477378769215688e-09,-1.0562072050301907e-12,-2.9668598439292371e-10 | 0.27909952771228624,0.026497254292227261,1.100313741479189
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.072Z | Extended Element | 5333562.831614011,2184681.3364562392,360.03094213066203 | 160.855 | 0 | 88.8607 | -1.8626460858138628e-09,8.3157942337708235e-12,-8.2822637637036678e-11 | 0.27910359413010599,0.025070525279719647,1.1003253878471759
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.087Z | Extended Element | 5333562.5960067557,2184682.8173273741,360.04526630599372 | -19.1454 | 0 | 90.0637 | 9.3132243364438646e-10,-1.0624140456272357e-13,3.8809200297496864e-10 | 0.27911335084879613,0.026480399186770143,1.1003092489145549
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.101Z | Extended Element | 5333562.2740078354,2184681.3281402057,360.03030364694706 | 160.855 | 0 | 88.8578 | 1.0477372720858356e-09,-1.4546960858119462e-11,-9.5516572429232838e-10 | 0.27911334037763708,0.025093099845950206,1.1003219122470682
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.112Z | Extended Element | 5333564.0080006672,2184685.2868985143,360.03556377691314 | -19.1454 | 0 | 88.9822 | 1.2805688522657018e-09,3.374229368136028e-11,-1.5337242587065703e-10 | 0.27908941223569189,0.0247514854891655,1.1003201921495354
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.123Z | Extended Element | 5333563.6859701322,2184683.7976936973,360.04677543176894 | 160.855 | 0 | 89.9392 | -8.1490729182788403e-10,-1.4069891085544128e-12,8.2482674704403858e-10 | 0.27908941592098147,0.026822467790228892,1.1003013243110464
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.136Z | Extended Element | 5333563.4504380859,2184685.2785830405,360.03509134306518 | -19.1454 | 0 | 88.9851 | -1.513399244488839e-09,-8.4638095143585446e-12,-4.5828318920814495e-10 | 0.27908075037305341,0.024728918394888666,1.1003232965789675
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.150Z | Extended Element | 5333563.1283981502,2184683.7893775236,360.04620709723605 | 160.855 | 0 | 89.9363 | 9.3132257461547852e-10,-1.2406742300186124e-14,1.1510403737148178e-11 | 0.27908077934218167,0.026845109283843979,1.1003040106081163
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.164Z | Extended Element | 5333564.8625168903,2184687.7485767063,359.9949804484209 | -19.1454 | 0 | 88.9798 | 5.8207717271308409e-10,-1.2168040880444764e-11,-1.2400483726734685e-10 | 0.27908472142582208,0.020931878529743798,1.1004561035036082
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.179Z | Extended Element | 5333564.5403951779,2184686.2591242031,360.02117474234768 | 160.855 | 0 | 91.0178 | 3.492452803971086e-10,1.4666372283311802e-11,-1.0782912341195326e-09 | 0.27908471896723647,0.0209577362741733,1.1004559364859663
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.192Z | Extended Element | 5333564.3049914055,2184687.7402611426,359.99455569360168 | -19.1454 | 0 | 88.9826 | -2.0954748564189938e-09,9.4892930319057101e-12,-5.3253936145421924e-10 | 0.27906608760037965,0.020954386214255757,1.1004623594884604
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.205Z | Extended Element | 5333563.9828495048,2184686.2508074138,360.02067677506182 | 160.855 | 0 | 91.0149 | 3.4924565329242541e-10,1.9018097860423744e-11,-1.7807444411886952e-10 | 0.27906608376819692,0.020980242766714945,1.1004621928699421
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.216Z | Extended Element | 5333565.6220001234,2184689.085365464,359.96986914236157 | 0.853849 | 180 | -88.9011 | -2.2591848782248657e-09,-1.8493498399330122e-11,-1.6874501829252528e-11 | 0.2381316550950823,0.019199374132316642,0.92406698482511651
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.227Z | Extended Element | 5333565.3948804596,2184688.7207080377,359.9748725012231 | 160.855 | 0 | 91.0202 | -8.1490725280817797e-10,2.6423823198951091e-11,-3.8405012503517355e-10 | 0.27908645729676407,0.020909459030637123,1.1004550901338426
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.242Z | Extended Element | 5333565.3220358538,2184689.9958918723,359.95246785709992 | -89.1454 | 0 | 90.0368 | -1.1105326232523925e-18,-6.8567027056154473e-13,-9.0143698064491408e-11 | 0.91489590074914462,0.036391023455796499,0.29026028821781802
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.255Z | Extended Element | 5333564.8373643961,2184688.7123916852,359.97444476105903 | 160.855 | 0 | 91.0174 | 1.0477382085720394e-09,-1.7915120775757742e-11,-4.2025586093864544e-10 | 0.27906739317378715,0.020931965396759011,1.1004615033519733
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.264Z | Complex Chain | 5333596.0271044709,2184690.3011750919,359.98587214573365 | 0 | 0 | 0 | -0.11357767414301634,-1.1217775028198957,0 | 0.01135474257171154,0,0.022752582575776614
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.273Z | Complex Chain | 5333596.1400480913,2184689.540773523,360.00121120321398 | 0 | 0 | 0 | -0.011354751884937286,0,-0.018527492110592902 | 0.26719318050891161,0.90927069215103984,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.283Z | Complex Chain | 5333596.6975223785,2184689.5490890867,360.00079134678697 | 0 | 0 | 0 | -0.2422228017821908,0,-0.01851821167417711 | 0,0.91426874697208405,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.292Z | Complex Chain | 5333596.584556466,2184690.3094903235,359.98543943740293 | 0 | 0 | 0 | -0.11355537548661232,-1.1217771712690592,0 | 0.011377041228115559,0,0.022765433674692304
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.304Z | Extended Element | 5333595.8878910569,2184690.2989077372,359.97634909427268 | 0.853808 | 0 | 88.841 | 5.6607310505718544e-10,-4.7215616832962937e-12,6.1459903778287181e-10 | 0.14875674430107463,0.019145354407777732,1.1234486122123024
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.317Z | Extended Element | 5333596.4207397867,2184689.5447596633,359.99147893946844 | 0.853809 | 180 | -88.8407 | 1.4413111815159141e-09,-3.1472453115855004e-11,-2.7582469654771201e-10 | 0.29024492996280316,0.019259256344358981,0.91490279923469675
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.328Z | Extended Element | 5333596.4453327423,2184690.3072185791,359.97591638919113 | 0.855485 | 0 | 88.8401 | 3.2999968035962723e-09,1.9095834288829217e-11,-2.9749802634554285e-10 | 0.14876712736180056,0.01913939677152119,1.1234453238710467
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.340Z | Extended Element | 5333596.7070491966,2184689.5490384432,359.99126829983231 | 0.855485 | 180 | -88.8397 | -3.7834981545040697e-10,-4.0394319833492176e-12,-6.0953642133654284e-10 | 0.23812871779570477,0.019229589399520592,0.92408483621290316
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.350Z | Complex Chain | 5333593.2795777963,2184679.7027561767,360.03923114912152 | 0 | 0 | 0 | -0.011361089535057545,0,0 | 0.11357326526194811,1.1217830120585859,0.022034676027942623
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.359Z | Complex Chain | 5333593.1666278103,2184680.4631576519,360.05427358558762 | 0 | 0 | 0 | -0.1135731628164649,-1.1217827247455716,-0.022056052748325783 | 0.01136108860373497,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.369Z | Complex Chain | 5333592.722125303,2184679.6944409395,360.03937028156548 | 0 | 0 | 0 | -0.011382810771465302,0,0 | 0.11355154402554035,1.1217826856300235,0.022047570223548973
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.384Z | Complex Chain | 5333592.6091535939,2184680.4548420887,360.0544256116749 | 0 | 0 | 0 | -0.11355144251137972,-1.1217824011109769,-0.0220689464432553 | 0.011382808908820152,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.399Z | Extended Element | 5333592.4699196229,2184680.4529498327,360.04490246398257 | 0.855918 | 0 | 91.13 | 1.9664490591431161e-09,-3.7577050845949422e-11,-8.0273299170287274e-10 | 0.14877170385546631,0.019071538102843413,1.1234358065694459
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.414Z | Extended Element | 5333592.8613537578,2184679.6967094708,360.02981153505056 | -179.144 | 0 | 88.8704 | -2.0466791039730481e-09,-2.8794546608201799e-11,7.379057364152894e-10 | 0.1487718052750395,0.019085604487262486,1.1234356718148779
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.428Z | Extended Element | 5333593.0274039004,2184680.4612693549,360.0447504347195 | 0.854285 | 0 | 91.129 | 7.6160117101764513e-10,1.3038545937371637e-12,-5.450147004848418e-10 | 0.1487615899360506,0.019065555539480299,1.1234390091602737
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.439Z | Extended Element | 5333593.4187962096,2184679.7050203094,360.02967838267296 | -179.146 | 0 | 88.8714 | 1.7870871449332526e-09,2.5876349674103238e-13,-4.6196291265752463e-10 | 0.14876169801676295,0.019079620102164793,1.1234388766431211
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.447Z | Complex Chain | 5333593.4636467481,2184682.9164254204,360.09482303804327 | 0 | 0 | 0 | -0.11356143560260534,-1.1217828346416354,-0.01443681354032833 | 0.011372919194400311,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.456Z | Complex Chain | 5333593.5766085638,2184682.1560241217,360.08737064850544 | 0 | 0 | 0 | -0.011372918263077736,0,0 | 0.11358265671879053,1.121843951754272,0.007409266443062279
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.465Z | Complex Chain | 5333594.0211098706,2184682.9247408179,360.09460081917854 | 0 | 0 | 0 | -0.11357214860618114,-1.1217829925008118,-0.014423921961565611 | 0.011362205259501934,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.474Z | Complex Chain | 5333594.1340609705,2184682.1643393612,360.08716132066377 | 0 | 0 | 0 | -0.011362204328179359,0,0 | 0.11359337065368891,1.1218441096134484,0.0073963752612371536
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.487Z | Extended Element | 5333593.3244181499,2184682.9144743145,360.08175961260986 | 0.855175 | 0 | 90.5575 | 9.118672483765522e-10,-2.131598716981209e-12,-7.9751583115239555e-10 | 0.14876721111898661,0.022589043787437646,1.1233089035878034
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.500Z | Extended Element | 5333593.7158552688,2184682.1582305357,360.07421657643675 | -179.145 | 0 | 89.4429 | 9.2335414314526076e-10,-3.1608968914520474e-12,-7.8563910980452963e-10 | 0.14878912758388907,0.022679693876970219,1.1233005138400574
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.514Z | Extended Element | 5333593.8818862438,2184682.9227915821,360.08153135794151 | 0.854369 | 0 | 90.5565 | 1.0311936027296298e-09,2.0599841277224584e-14,-1.2284973042130698e-10 | 0.14876221449697621,0.02259507772948055,1.1233104306278421
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.527Z | Extended Element | 5333594.2733027339,2184682.1665434618,360.07401329039237 | -179.146 | 0 | 89.4439 | 1.9207714030411438e-09,8.1137145613308093e-12,-9.7453600772059653e-10 | 0.14878415096348616,0.022673649644563199,1.1233021459512826
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.535Z | Complex Chain | 5333594.3181379987,2184685.3780087237,360.08616450616415 | 0 | 0 | 0 | -0.11359768360853195,-1.1218441762030125,0 | 0.01135789230465889,0,0.0079663141742685184
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.547Z | Complex Chain | 5333594.4310847782,2184684.6176072019,360.09393079048374 | 0 | 0 | 0 | -0.011357893235981464,0,-0.01514278738466146 | 0.11357462964951992,1.1217777542769909,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.556Z | Complex Chain | 5333594.8755900264,2184685.386323954,360.08587209979311 | 0 | 0 | 0 | -0.11356331501156092,-1.1217775847762823,0 | 0.011369207873940468,0,0.015150694384999497
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.568Z | Complex Chain | 5333594.9885481251,2184684.6259226026,360.09365126812799 | 0 | 0 | 0 | -0.011369212530553341,0,-0.007984175152557782 | 0.11358636245131493,1.1218440048396587,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.581Z | Extended Element | 5333594.1788983261,2184685.3757992112,360.0731169728694 | 0.854045 | 0 | 89.4122 | 4.7934053948317512e-10,-4.2443357856081221e-12,-6.5665961565428924e-10 | 0.14878213830628084,0.02257321985331729,1.1233079713261962
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.595Z | Extended Element | 5333594.570304634,2184684.6195473457,360.08076109150193 | -179.146 | 0 | 90.5881 | -7.2559491748336313e-10,-1.0396237690168952e-11,-9.6939034604216598e-10 | 0.1487583077588468,0.022695392845381687,1.1233150326691046
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.607Z | Extended Element | 5333594.7363684056,2184685.384148628,360.0763476026267 | 0.854896 | 0 | 89.4113 | -8.5334592170305257e-10,8.4092767471677377e-12,-5.4009863253366892e-10 | 0.14876358045979285,0.022691700695874756,1.1233133453081303
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.618Z | Extended Element | 5333595.1277964953,2184684.6279025027,360.08412677160095 | -179.145 | 0 | 90.5891 | -5.9370164340322162e-10,1.0196340299861717e-12,6.202474085188948e-10 | 0.14878741011592211,0.022581590597312559,1.1233062727712892
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.629Z | Complex Chain | 5333595.1726212455,2184687.8395919083,360.03606576554284 | 0 | 0 | 0 | -0.11357972491532564,-1.1217778320424259,0 | 0.011352794244885445,0,0.022753550788422672
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.637Z | Complex Chain | 5333595.2855629213,2184687.0791903101,360.05143499439316 | 0 | 0 | 0 | -0.011352796107530594,0,-0.022758524300968475 | 0.11357972305268049,1.1217778315767646,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.647Z | Complex Chain | 5333595.7300731391,2184687.8479071376,360.03570315177564 | 0 | 0 | 0 | -0.11355739925056696,-1.1217774986289442,0 | 0.011375119909644127,0,0.022766417183675003
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.655Z | Complex Chain | 5333595.8430371415,2184687.0875058747,360.05108524619664 | 0 | 0 | 0 | -0.011375129222869873,0,-0.022771390619993781 | 0.11355738993734121,1.1217774972319603,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.666Z | Extended Element | 5333595.0334086409,2184687.8373247054,360.02654271848053 | 0.853661 | 0 | 88.8397 | -1.0640557601693246e-09,-2.4275690832520347e-11,9.4829566405069873e-10 | 0.14875592972487797,0.019120746510719447,1.1234492490914596
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.680Z | Extended Element | 5333595.4247812973,2184687.0810703654,360.04184355091712 | 0.853661 | 180 | -88.8394 | -9.9796723662670672e-10,1.0712094405951333e-11,-7.8838180476444915e-10 | 0.14875593349018604,0.019118411718640274,1.1234493452209866
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.695Z | Extended Element | 5333595.590850208,2184687.8456355389,360.02618010796994 | 0.85534 | 0 | 88.8388 | -8.846224586189777e-10,-3.3882225150549949e-11,9.1448093490753771e-10 | 0.14876632749031415,0.019114781851210037,1.1234459535041976
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.709Z | Extended Element | 5333595.9822658598,2184687.0893901247,360.04149977118709 | 0.855341 | 180 | -88.8384 | -8.4754414597654204e-10,6.1064868439597575e-12,1.449121711385036e-09 | 0.14876633170309359,0.019112445302486236,1.1234460525271985
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.769Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333591.6534361942,2184677.0000275779,359.84711604795314 | 5333596.7981915371,2184690.5423128833,360.95276461621927
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.861Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333560.567295203,2184676.5363313025,359.8124712951647 | 5333565.7120083366,2184690.0786154815,360.92406557095859
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.870Z | Line | 5333560.9015732883,2184677.1519956179,360.76567602465394 | 0 | 0 | 0 | 0,0,0 | 0.2031778022646904,0.0030307010747492313,0.0011602729712194559
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.881Z | Line | 5333561.0031621894,2184677.1535109687,360.76625616113955 | 0 | 0 | 0 | 0,0,-0.065604850760109912 | 2.7939677238464355e-09,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.889Z | Line | 5333561.7563039195,2184679.6038613752,360.81769646405604 | 0 | 0 | 0 | 0,0,0 | 0.20303283166140318,0.0127496556378901,0.0011253253645122641
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.901Z | Line | 5333561.0031621894,2184677.1535109687,360.76625616113955 | 0 | 0 | 0 | 0,0,0 | 0.85465814545750618,2.4567252341657877,0.05200296559871731
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:34.959Z | Extended Element | 5333560.567295203,2184676.536331302,359.81247129516464 | 0 | 0 | 0 | 3.3634428575624042e-11,2.5443647189149488e-10,2.8643754035329039e-14 | 5.1447131331885538,13.542284179298022,1.1115942757939723
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.001Z | Extended Element | 5333561.0181281613,2184678.0434337449,360.91810744497849 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.012Z | Extended Element | 5333561.0941161066,2184678.2618620191,360.92273104626014 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.022Z | Extended Element | 5333561.1701040529,2184678.4802902914,360.92735464754236 | 70.8964 | -179.987 | 0.00016216 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.034Z | Extended Element | 5333561.2460919973,2184678.6987185627,360.93197824882401 | 70.8964 | -179.987 | 0.000161803 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:35.045Z | Extended Element | 5333561.3220799435,2184678.9171468345,360.93660185010594 | 70.8964 | -179.987 | 0.000162222 | -0.011397382376816151,-0.71466128900868431,-0.011397383543039001 | 0.011397385526429254,0.15586017243840325,1.0115243816065584
