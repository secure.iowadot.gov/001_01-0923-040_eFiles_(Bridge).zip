Properties of the parts of a building model (IFC4X3_ADD2), part 33 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.547Z | Line | 5333593.6985867536,2184682.4563274072,360.51353848152962 | 0 | 0 | 0 | -0.002462443895637989,0,-2.2737367544323206e-13 | 0,0.16508196573704481,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.556Z | Line | 5333594.7557415944,2184684.9209337416,360.5128944797334 | 0 | 0 | 0 | -0.002462443895637989,0,0 | 0,0.1650819662027061,1.1368683772161603e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.573Z | Line | 5333594.5531236669,2184684.9179113926,360.51246697066637 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196527138352,3.979039320256561e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.582Z | Line | 5333595.6102784872,2184687.3825177262,360.46274150093808 | 0 | 0 | 0 | -0.0024624448269605637,0,-1.1368683772161603e-13 | 0,0.16508196573704481,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.591Z | Line | 5333595.4076605793,2184687.3794953772,360.46233949819458 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.1650819662027061,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.602Z | Line | 5333596.4648154732,2184689.8441017116,360.41247628573996 | 0 | 0 | 0 | -0.002462443895637989,0,-7.3896444519050419e-13 | 0,0.16508196573704481,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.612Z | Line | 5333596.2621974899,2184689.8410793608,360.41209982422276 | 0 | 0 | 0 | -0.0024624457582831383,0,0 | 0,0.16508196666836739,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.620Z | Line | 5333610.5856728479,2184690.0547354408,360.40156503217634 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196573704481,6.8212102632969618e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.628Z | Line | 5333609.7311358619,2184687.5931514581,360.45360558775172 | 0 | 0 | 0 | -0.0024624448269605637,0,0 | 0,0.16508196573704481,3.979039320256561e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.636Z | Line | 5333608.8765989663,2184685.1315674726,360.50553738010143 | 0 | 0 | 0 | -0.0024624448269605637,0,-5.6843418860808015e-14 | 0,0.16508196527138352,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.644Z | Line | 5333608.0220620539,2184682.669983489,360.50841233846415 | 0 | 0 | 0 | -0.002462443895637989,0,-1.7053025658242404e-13 | 0,0.16508196527138352,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.653Z | Line | 5333607.1675251434,2184680.2083995035,360.46223151900455 | 0 | 0 | 0 | -0.002462443895637989,0,0 | 0,0.16508196527138352,2.8421709430404007e-13
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.661Z | Line | 5333606.312988231,2184677.746815518,360.41593847297565 | 0 | 0 | 0 | -0.0024624457582831383,0,0 | 0,0.16508196573704481,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.672Z | Line | 5333565.377940068,2184689.4629537682,360.39130474265312 | 0 | 0 | 0 | 0,0,0 | 30.883026199415326,0.46066657546907663,0.020795080949767453
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.682Z | Line | 5333564.5234031565,2184687.0013697818,360.43765563826389 | 0 | 0 | 0 | 0,0,0 | 30.883026200346649,0.46066657826304436,0.024683859935578312
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.692Z | Line | 5333563.6688662432,2184684.5397857963,360.48389433298257 | 0 | 0 | 0 | 0,0,0 | 30.883026202209294,0.46066658012568951,0.028572638149341856
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.699Z | Line | 5333562.8143293317,2184682.0782018108,360.48107706606737 | 0 | 0 | 0 | 0,0,0 | 30.883026199415326,0.46066657966002822,0.032461415391139781
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.707Z | Line | 5333561.9597924212,2184679.6166178272,360.42920383816369 | 0 | 0 | 0 | 0,0,0 | 30.883026200346649,0.46066657826304436,0.036350192430461448
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.717Z | Line | 5333561.1052555107,2184677.1550338431,360.3772184067754 | 0 | 0 | 0 | 0,0,0 | 30.883026196621358,0.4606665768660605,0.040238971443784521
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.724Z | Line | 5333592.1908996338,2184677.6187227685,360.41796142990296 | 0 | 0 | 0 | 0,0,-0.0020229570690162291 | 14.120857374742627,0.21063373191282153,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.734Z | Line | 5333593.0454365462,2184680.0803067568,360.46603256806952 | 0 | 0 | 0 | 0,0,-0.0038010494885725166 | 14.120857376605272,0.21063372958451509,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.742Z | Line | 5333593.8999734567,2184682.5418907409,360.51399150536832 | 0 | 0 | 0 | 0,0,-0.0055791667746802887 | 14.120857374742627,0.21063373144716024,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.752Z | Line | 5333594.7545103719,2184685.0034747254,360.51289448032321 | 0 | 0 | 0 | 0,0,-0.0073570999356888933 | 14.120857371017337,0.21063372958451509,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.760Z | Line | 5333595.6090472648,2184687.46505871,360.46274150112407 | 0 | 0 | 0 | 0,0,-0.0091359140593567645 | 14.120857373811305,0.21063373005017638,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.769Z | Line | 5333596.4635842508,2184689.926642694,360.41247628511212 | 0 | 0 | 0 | 0,0,-0.010911252822040751 | 14.120857374742627,0.21063373005017638,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.778Z | Line | 5333565.3767088456,2184689.5454947515,360.39130474271229 | 0 | 0 | 0 | 0,0,0 | 30.883026199415326,0.46066657546907663,0.020795080949767453
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.788Z | Line | 5333564.5221719351,2184687.0839107651,360.43765563827253 | 0 | 0 | 0 | 0,0,0 | 30.883026200346649,0.46066657826304436,0.024683859935521468
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.798Z | Line | 5333563.6676350208,2184684.6223267801,360.48389433299053 | 0 | 0 | 0 | 0,0,0 | 30.883026202209294,0.46066657966002822,0.028572638149285012
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.807Z | Line | 5333562.8130981103,2184682.1607427946,360.48107706593646 | 0 | 0 | 0 | 0,0,0 | 30.883026199415326,0.46066657966002822,0.032461415391139781
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.817Z | Line | 5333561.9585611988,2184679.6991588105,360.42920383813998 | 0 | 0 | 0 | 0,0,0 | 30.883026200346649,0.46066657872870564,0.036350192430518291
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.824Z | Line | 5333561.1040242882,2184677.2375748265,360.37721840683372 | 0 | 0 | 0 | 0,0,0 | 30.883026196621358,0.4606665768660605,0.040238971443841365
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.835Z | Line | 5333592.1896684114,2184677.7012637514,360.41796142994383 | 0 | 0 | 0 | 0,0,-0.0020229570690162291 | 14.120857374742627,0.21063373191282153,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.842Z | Line | 5333593.0442053238,2184680.1628477401,360.46603256789876 | 0 | 0 | 0 | 0,0,-0.0038010494885725166 | 14.120857376605272,0.21063372958451509,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.852Z | Line | 5333593.8987422343,2184682.6244317247,360.51399150527419 | 0 | 0 | 0 | 0,0,-0.0055791667746802887 | 14.120857374742627,0.21063373144716024,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.861Z | Line | 5333594.7532791505,2184685.0860157078,360.51289448036101 | 0 | 0 | 0 | 0,0,-0.0073570999356888933 | 14.120857370086014,0.21063372958451509,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.871Z | Line | 5333595.6078160433,2184687.547599691,360.46274150072014 | 0 | 0 | 0 | 0,0,-0.0091359140593567645 | 14.120857374742627,0.21063373005017638,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.879Z | Line | 5333596.4623530284,2184690.0091836778,360.41247628583199 | 0 | 0 | 0 | 0,0,-0.010911252822040751 | 14.120857373811305,0.21063373005017638,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.889Z | Line | 5333557.655054979,2184689.1254826756,360.46526518711613 | 0 | 0 | 0 | 0,0,0 | 0.072736363857984543,0.0010842764750123024,0.00015048115449189936
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.899Z | Line | 5333557.6552388594,2184689.1254854207,360.3763653773064 | 0 | 0 | 0 | 0,0,0 | 0.072736363857984543,0.0010842764750123024,0.0001504811546055862
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.910Z | Line | 5333557.6554227406,2184689.1254881676,360.28746556754754 | 0 | 0 | 0 | 0,0,0 | 0.072736362926661968,0.0010842764750123024,0.0001504811494896785
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.919Z | Line | 5333557.6847326141,2184687.1216356638,360.51283288027105 | 0 | 0 | 0 | 0,0,0 | 0.072736362926661968,0.0010842764750123024,0.0001504811494896785
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.926Z | Line | 5333557.6849164953,2184687.1216384103,360.42393307048553 | 0 | 0 | 0 | 0,0,0 | 0.072736361995339394,0.0010842764750123024,0.00015048115062654688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.934Z | Line | 5333557.6851003775,2184687.1216411544,360.33503326067938 | 0 | 0 | 0 | 0,0,0 | 0.072736361064016819,0.0010842760093510151,0.00015048114551063918
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.942Z | Line | 5333580.8194531677,2184689.6932870564,360.4017022830979 | 0 | 0 | 0 | -0.85576813295483589,-2.3790430026128888,0 | 0,0,0.048295285142387456
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.950Z | Line | 5333603.5240129391,2184690.0319595593,360.40702065870107 | 0 | 0 | 0 | -0.85576820839196444,-2.3790430035442114,0 | 0,0,0.051152884989392078
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.958Z | Line String | 5333580.3915691013,2184688.5037655551,360.42584992566907 | 0 | 0 | 0 | -0.018825020641088486,0,-0.024447605889292845 | 0,1.265417514834553,8.943175089370925e-10
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.967Z | Line String | 5333603.0961288344,2184688.8424380571,360.43259710119577 | 0 | 0 | 0 | -0.018823397345840931,0,-0.025232220547138695 | 0,1.2654175399802625,8.9244167611468583e-10
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.978Z | Extended Element | 5333580.5427186685,2184689.7717184974,360.33825383600748 | -179.145 | -0.118524 | 90 | 5.3057923034886665e-10,3.1896963250633657e-12,-4.8423169017218647e-09 | 0.33972500081688362,0.12700000101562142,0.012700004223173654
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:41.992Z | Extended Element | 5333580.5360453278,2184689.3778740093,360.26202770492233 | 0.855355 | 90.1185 | -0.00186478 | -1.6504714261955655e-12,-6.2928018351726678e-10,-9.1231813770242809e-10 | 0.27940000176528312,0.22859999795167654,0.1524000046774745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.008Z | Extended Element | 5333580.3741386402,2184689.3754619421,360.2616927431626 | 0.855355 | 90.1185 | -0.00076484 | -1.1947942635259778e-12,-2.8067209667526072e-10,-6.5192580223083496e-09 | 0.27940000168929613,0.22859999820590732,0.15239999809177085
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.022Z | Extended Element | 5333580.300903935,2184689.7985603493,360.34723358882576 | -89.1454 | -0.00000157981 | 90 | -6.4345456740610985e-10,-7.6116196678910342e-14,-1.552862192999438e-09 | 0.24923849957129046,0.044450000000074166,0.044449999856911074
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.035Z | Extended Element | 5333580.2961520124,2184687.1236393135,360.39480129346782 | 90.8546 | 0.00000158685 | 90 | -2.6186317003684678e-10,-2.4879404092459367e-14,-3.1972753611331228e-10 | 0.2492364995782676,0.04445000000000833,0.044450001163463565
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.049Z | Extended Element | 5333580.2487833565,2184687.5471248436,360.30894518793053 | -179.145 | 89.8815 | -0.00186478 | -1.7685869574401991e-09,3.5463423864179333e-10,-5.4340421051790599e-10 | 0.27939999999834653,0.22859999931408045,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.065Z | Extended Element | 5333580.4106900468,2184687.5495369108,360.30928014973921 | -179.145 | 89.8815 | -0.00076484 | -1.6906673144800877e-09,4.9627982279254468e-10,-8.3819031715393066e-09 | 0.27939999999982351,0.22859999979796503,0.1524000003265106
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.076Z | Extended Element | 5333580.5816751076,2184687.1456421893,360.3858215047494 | -179.145 | -0.118524 | 90 | 4.9617400813871823e-10,3.0191660683976032e-12,-2.469148126288372e-09 | 0.33972500078154066,0.12700000101545048,0.01270000465596844
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.089Z | Extended Element | 5333579.7271235175,2184684.684057984,360.43145165513505 | -179.145 | -0.118524 | 90 | -8.7519307764414994e-11,2.223358204346291e-12,-2.9348094135961112e-09 | 0.33972500019784735,0.12700000101465467,0.012700004190307153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.103Z | Extended Element | 5333579.4414690807,2184684.6620531469,360.50393130792907 | 90.8546 | 0.00000158685 | 90 | 6.6645289287237119e-10,-1.5189238755652923e-13,-2.0148556850729804e-09 | 0.24923650027239336,0.044449999999935416,0.044449999462690432
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.114Z | Extended Element | 5333579.4416004242,2184684.6620551082,360.44043144385353 | 90.8546 | 0.00000158685 | 90 | -6.2927849042715422e-10,-3.7872482927525652e-14,-2.2717770130353809e-09 | 0.24923649944504273,0.04445000000002132,0.0444499992057691
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.126Z | Extended Element | 5333579.6287772311,2184684.6648471304,360.50431882292173 | 90.8546 | 0.00000158685 | 90 | -2.2666230004020349e-11,-8.2388956768042476e-14,-3.3967773385712441e-10 | 0.24923649981746454,0.04444999999999194,0.04445000034818769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.139Z | Extended Element | 5333579.6289085746,2184684.6648490936,360.44081895877531 | 90.8546 | 0.00000158685 | 90 | 3.1277658241180006e-10,-8.2045481519799068e-14,-9.2710002175255823e-10 | 0.2492365003870978,0.04444999999999226,0.044450000550446095
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.154Z | Extended Element | 5333579.5561384577,2184685.0879527065,360.35491030012486 | -179.145 | 89.8815 | -0.00076484 | -1.6936231722608497e-09,-7.6375095137137805e-10,-5.5879354476928711e-09 | 0.27939999999686765,0.22859999886664245,0.15240000265159498
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.168Z | Extended Element | 5333579.3942317674,2184685.0855406383,360.35457533831783 | -179.145 | 89.8815 | -0.00186478 | -1.7678479929950086e-09,-3.8917233324831102e-10,-5.1063847594789991e-11 | 0.27939999999908549,0.22859999831410469,0.1524000046774745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.182Z | Extended Element | 5333579.6814937396,2184686.916289805,360.30765785531116 | 0.855355 | 90.1185 | -0.00186478 | -9.6835039986586935e-13,-8.1679402130774292e-10,-2.9899061004812211e-10 | 0.27940000176596524,0.2285999978484434,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.199Z | Extended Element | 5333579.5195870502,2184686.9138777372,360.3073228935483 | 0.855355 | 90.1185 | -0.00076484 | -5.1267323719628166e-13,4.8036102873183495e-11,-5.5879354476928711e-09 | 0.27940000168997825,0.22859999886664245,0.15239999757700293
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.211Z | Extended Element | 5333579.4462210033,2184687.3369741836,360.45636360326318 | -89.1454 | -0.00000157979 | 90 | 2.2164220458975592e-10,-1.4222303890143451e-13,-9.1976964933238037e-10 | 0.24923849950014709,0.044449999999946567,0.04445000048435746
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.226Z | Extended Element | 5333579.4463523459,2184687.3369761449,360.39286373921146 | -89.1454 | -0.00000157979 | 90 | -3.612519450246765e-10,-1.9873339085485497e-13,5.8640622566108469e-10 | 0.24923849985401442,0.044449999999841783,0.044450001055520133
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.241Z | Extended Element | 5333579.6335291546,2184687.3397681699,360.45675111827967 | -89.1454 | -0.00000157981 | 90 | 5.3049856174602894e-10,-1.8946302859923492e-13,-1.2636943262644973e-09 | 0.2492385002768629,0.044449999999903629,0.044450000713842613
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.255Z | Extended Element | 5333579.6336604981,2184687.3397701299,360.3932512541333 | -89.1454 | -0.00000157981 | 90 | -4.9650727973471476e-11,-1.3295961553971836e-13,-3.9957295111525681e-10 | 0.2492385001650943,0.044449999999960153,0.044450001010200316
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.265Z | Extended Element | 5333579.6881670784,2184687.3101342926,360.38388398639313 | -179.145 | -0.118524 | 90 | 8.6729444161763434e-10,4.8381554720267981e-12,-6.2393007636450824e-09 | 0.33972500115359883,0.12700000101726988,0.012700002826189792
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.276Z | Extended Element | 5333578.7743901759,2184682.2032653838,360.5009770692202 | 90.8546 | 0.00000158685 | 90 | 5.8191371166138595e-10,-2.4868995751603507e-14,-1.298096956314776e-09 | 0.24923650065623493,0.044450000000008316,0.044449999378478149
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.288Z | Extended Element | 5333578.7745215194,2184682.203267348,360.43747720507383 | 90.8546 | 0.00000158685 | 90 | 9.2007607088717691e-10,-2.4879404092459367e-14,8.9895927507521733e-10 | 0.24923650076020684,0.04445000000000833,0.044450001736171384
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.303Z | Extended Element | 5333578.5870820247,2184682.2004714003,360.50058955422747 | 90.8546 | 0.00000158685 | 90 | 5.7118121343791017e-10,-6.5645405777914334e-14,-1.9423531533169225e-10 | 0.24923650064550243,0.044450000000021653,0.044450001288955793
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.318Z | Extended Element | 5333578.5872133682,2184682.200473363,360.43708969015205 | 90.8546 | 0.00000158685 | 90 | 1.3750048599714404e-09,-8.81239525796218e-15,-1.6603407711202056e-09 | 0.24923650121513563,0.04445000000007851,0.044449999822850333
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.333Z | Extended Element | 5333578.7017514026,2184682.6263709599,360.35156854642338 | -179.145 | 89.8815 | -0.00076484 | -1.6897578197783147e-09,2.5985077978241122e-10,-8.3819031715393066e-09 | 0.27940000000073301,0.22859999933230374,0.15239999863225864
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.347Z | Extended Element | 5333578.5398447113,2184682.6239588927,360.3512335846147 | -179.145 | 89.8815 | -0.00186478 | -1.7731344309490638e-09,-1.6418405524021296e-10,2.0556798763227135e-09 | 0.27939999999379905,0.22859999877976597,0.15240000747144222
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.360Z | Extended Element | 5333578.8727364615,2184682.2224762384,360.42810990143357 | -179.145 | -0.118524 | 90 | -2.0433397681330748e-10,-5.0512590097249373e-13,-4.331793275519329e-09 | 0.33972500008103268,0.12700000101192618,0.012700003258984578
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.374Z | Extended Element | 5333578.8268882753,2184684.4547047964,360.35323537896386 | 0.855355 | 90.1185 | -0.00186478 | -3.999162112577892e-13,-7.6529504955402672e-11,-2.6855231927136458e-10 | 0.27940000176653368,0.22859999841009598,0.15240000374615192
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.386Z | Extended Element | 5333578.6649815878,2184684.4522927292,360.35290041720253 | 0.855355 | 90.1185 | -0.00076484 | 5.5760951411798487e-14,-9.0370211314194648e-11,-7.4505805969238281e-09 | 0.27940000169054668,0.22859999933230374,0.15239999860112685
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.399Z | Extended Element | 5333578.59161554,2184684.8753891755,360.50194112691742 | -89.1454 | -0.00000157981 | 90 | 2.1580073839011504e-10,-1.8979262605967051e-13,8.8638455256195847e-10 | 0.24923849996216507,0.044449999999903303,0.044450002296157823
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.411Z | Extended Element | 5333578.5917468844,2184684.8753911364,360.43844126286569 | -89.1454 | -0.00000157981 | 90 | -8.3000986639270025e-10,-7.5783129771522795e-14,-1.3418594221881186e-09 | 0.24923849938473513,0.044450000000017323,0.044450000067913845
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.425Z | Extended Element | 5333578.7789236931,2184684.8781831618,360.50232864193379 | -89.1454 | -0.00000157979 | 90 | 3.5125416464332204e-10,-1.4222997779533841e-13,-3.0882716869906623e-10 | 0.24923849962975902,0.04444999999994656,0.044450000739342674
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.440Z | Extended Element | 5333578.7790550366,2184684.8781851223,360.43882877778742 | -89.1454 | -0.00000157979 | 90 | -2.2892052142786667e-10,-8.5046553133238945e-14,5.5186347158731053e-10 | 0.24923849951796512,0.04444999999995547,0.044450001020977375
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.453Z | Extended Element | 5333578.8335616169,2184684.8485492845,360.42946151004736 | -179.145 | -0.118524 | 90 | -8.8208375623961989e-10,2.6781055553160935e-12,-5.3079781890296039e-09 | 0.33972499940422063,0.12700000101510983,0.012700004223173654
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.467Z | Extended Element | 5333577.9243153632,2184682.4165981133,360.49890909179481 | -89.1454 | -0.00000157981 | 90 | 7.6506406765375345e-10,-1.3295267664581445e-13,-5.7067740810712309e-10 | 0.24923850051142837,0.044450000000017316,0.044450000477323962
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.482Z | Extended Element | 5333577.737007211,2184682.4138041269,360.49852157677833 | -89.1454 | -0.00000157979 | 90 | 9.2188584543961838e-10,-8.5379620040626492e-14,4.5902431855537884e-10 | 0.24923850020039073,0.04445000000006058,0.044450001863151428
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.494Z | Extended Element | 5333577.7371385535,2184682.4138060873,360.43502171272661 | -89.1454 | -0.00000157979 | 90 | 3.4443059515609775e-10,-1.4222303890143451e-13,-3.6337018394227982e-09 | 0.24923849962293548,0.044450000000003737,0.044449998707186765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.508Z | Extended Element | 5333577.9244467057,2184682.4166000728,360.43540922764845 | -89.1454 | -0.00000157981 | 90 | 1.8763421372192113e-10,-1.329492071988625e-13,2.9886901981024394e-10 | 0.24923849993399855,0.044449999999960146,0.044450001708642287
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.526Z | Extended Element | 5333577.9722799473,2184681.9931197478,360.3498158288233 | 0.855355 | 90.1185 | -0.00186478 | -5.1360304897940523e-13,1.5890305737897847e-10,5.2967649710744524e-10 | 0.27940000176641999,0.22859999864553188,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.543Z | Extended Element | 5333577.8103732588,2184681.990707681,360.34948086706345 | 0.855355 | 90.1185 | -0.00076484 | -1.99060212757729e-12,-1.847976771607307e-10,-4.6572761766772641e-09 | 0.27940000168850032,0.22859999867997882,0.1523999996862026
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.555Z | Extended Element | 5333577.978953287,2184682.3869642359,360.42604195990833 | -179.145 | -0.118524 | 90 | 5.783889865029047e-10,1.8254542724039733e-12,-5.7736394763373432e-09 | 0.33972500086469337,0.12700000101425718,0.012700003291851079
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.571Z | Extended Element | 5333577.8471270697,2184680.1647856692,360.29921265144918 | -179.145 | 89.8815 | -0.00076484 | -1.6965221449893875e-09,-1.5703890965390599e-10,-4.6566128730773926e-09 | 0.27939999999396858,0.22859999933230374,0.15240000267850234
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.586Z | Extended Element | 5333577.6852203794,2184680.162373601,360.29887768964215 | -179.145 | 89.8815 | -0.00186478 | -1.7688711329011397e-09,-3.6454300689214847e-10,2.7420654635790243e-10 | 0.2793999999980622,0.22859999831410469,0.1524000046774745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.599Z | Extended Element | 5333577.7325890362,2184679.7388880705,360.38473379517785 | 90.8546 | 0.00000158685 | 90 | -3.0921873395151067e-10,-8.2045481519799068e-14,-2.4225153792689635e-09 | 0.24923649976510248,0.044449999999992246,0.04444999841469674
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.613Z | Extended Element | 5333577.7324576937,2184679.7388861096,360.44823365925333 | 90.8546 | 0.00000158685 | 90 | 7.5232231555588669e-10,-2.5212470999846914e-14,9.2078714791776761e-10 | 0.24923650059245309,0.044450000000049103,0.044450001757999257
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.625Z | Extended Element | 5333577.919765844,2184679.7416800926,360.44862117424606 | 90.8546 | 0.00000158685 | 90 | -4.0245817789497096e-10,1.8970935933282362e-14,-1.9215139895889521e-10 | 0.24923649967186304,0.044450000000078163,0.044450000484423706
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.638Z | Extended Element | 5333577.9198971866,2184679.7416820559,360.38512131009963 | 90.8546 | 0.00000158685 | 90 | 1.6717505157970436e-10,1.8970935933282362e-14,-2.6607849465398736e-09 | 0.24923650024149627,0.044450000000078163,0.044449998176427169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.649Z | Extended Element | 5333578.0181121305,2184679.7608909472,360.37575400645943 | -179.145 | -0.118524 | 90 | 2.0079456050990433e-09,4.4402518329577025e-12,-4.7974545628270683e-09 | 0.33972500229331221,0.12700000101687145,0.012700003258984578
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.669Z | Extended Element | 5333577.7633062257,2184680.0435563806,360.24739580656421 | 90.8543 | 1.43742 | 89.8814 | -5.1079141196943507e-10,1.7223555914824829e-11,-4.8062503976709081e-10 | 2.0859791715917506,0.38100000003083045,0.085726458579301834
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.690Z | Extended Element | 5333580.3271441786,2184687.4096771348,360.25942900256422 | 90.8486 | -1.35969 | 89.8814 | 6.5852212571826385e-10,-1.4085799193708226e-10,8.2135226397994643e-10 | 2.0859791738994748,0.38100000002606071,0.085726433441242436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.710Z | Extended Element | 5333579.4725823971,2184684.9480923079,360.30505958807782 | 90.8485 | -1.35967 | 89.8814 | -7.9582563271345431e-11,-2.734169166722292e-11,-2.4262128556218343e-09 | 2.0859791722147545,0.3809999999837268,0.085726454924984208
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.733Z | Extended Element | 5333578.5861736415,2184684.5809873552,360.68296967883015 | -89.1453 | -0.0386396 | -89.8815 | 2.0259099953179316e-10,-1.2846612662542611e-11,-6.1060144440627795e-10 | 2.0859791719897585,0.38100000000096945,0.085725019685924053
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.746Z | Extended Element | 5333577.1256235642,2184679.9254011461,360.37362572533004 | -179.145 | -0.118524 | 90 | 4.3787038987586877e-10,5.4065896606352918e-12,-4.3766556144141254e-09 | 0.33972500072417477,0.12700000101783826,0.012700004688834941
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.758Z | Extended Element | 5333577.1256235642,2184679.9254011461,360.37362572533004 | -179.145 | -0.118524 | 90 | 4.3787038987586877e-10,5.4065896606352918e-12,-4.3766556144141254e-09 | 0.33972500072417477,0.12700000101783826,0.012700004688834941
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.772Z | Extended Element | 5333576.8838088308,2184679.9522429984,360.38260547814832 | -89.1454 | -0.00000157979 | 90 | 1.5850398771277696e-10,-2.8543140073722384e-14,-1.2255978280861779e-09 | 0.24923849967119927,0.044450000000060247,0.044450000757585109
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.785Z | Extended Element | 5333576.8836774891,2184679.952241038,360.44610534220004 | -89.1454 | -0.00000157979 | 90 | 9.6743013600075756e-10,-8.5053492027142852e-14,7.6798584852655338e-11 | 0.24923850071431575,0.044449999999955483,0.044450001124968427
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.796Z | Extended Element | 5333577.0709856413,2184679.9550350239,360.44649285721647 | -89.1454 | -0.00000157981 | 90 | -1.1797382515332799e-10,-7.6105788338054481e-14,6.5907888174843166e-10 | 0.24923849962839051,0.04445000000001699,0.044450001139316651
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.807Z | Extended Element | 5333577.071116982,2184679.9550369838,360.3829929930701 | -89.1454 | -0.00000157981 | 90 | -2.2974239177742106e-10,-1.3295267664581445e-13,-1.8476079693963143e-09 | 0.24923849951662191,0.044449999999960146,0.044450000129928967
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.821Z | Extended Element | 5333576.9570435351,2184679.5291445912,360.2970646324851 | 0.855355 | 90.1185 | -0.00076484 | -3.5821901001042988e-12,-2.3523546999193456e-10,-6.5192580223083496e-09 | 0.27940000168690865,0.22859999900803052,0.15239999981719721
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.837Z | Extended Element | 5333577.1189502226,2184679.5315566584,360.29739959424336 | 0.855355 | 90.1185 | -0.00186478 | -2.048347602645606e-12,-1.0417873230750274e-09,-4.2685277534815214e-10 | 0.27940000176488511,0.2285999978484434,0.15240000374615192
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.852Z | Extended Element | 5333576.9939143658,2184677.7032214385,360.24679986614905 | -179.145 | 89.8815 | -0.00076484 | -1.6905536553979417e-09,3.5896494110509991e-10,-6.5192580223083496e-09 | 0.27939999999993725,0.22859999979796503,0.1524000010462013
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.866Z | Extended Element | 5333576.8320076754,2184677.7008093707,360.24646490434202 | -179.145 | 89.8815 | -0.00186478 | -1.7647784761321006e-09,3.702538553529422e-10,-1.3434950096868903e-09 | 0.27940000000215509,0.22859999971108855,0.15240000374615192
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.879Z | Extended Element | 5333576.8793763304,2184677.2773238407,360.33232100987777 | 90.8546 | 0.00000158685 | 90 | 3.360080547132327e-10,-2.4879404092459367e-14,-1.056230217871823e-09 | 0.24923650017613883,0.04445000000000833,0.04445000135807739
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.893Z | Extended Element | 5333576.8792449897,2184677.2773218788,360.3958208739532 | 90.8546 | 0.00000158685 | 90 | 2.3203611254629664e-10,-2.4879404092459367e-14,-5.0873245199811734e-10 | 0.24923650007216688,0.04445000000000833,0.044450000317189667
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.907Z | Extended Element | 5333577.0666844826,2184677.2801178256,360.3327085247995 | 90.8546 | 0.00000158685 | 90 | 1.1255013587785356e-10,-8.81239525796218e-15,-1.2836219448475461e-09 | 0.24923650018687135,0.044450000000078496,0.044450000193924172
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.922Z | Extended Element | 5333577.0665531401,2184677.2801158628,360.39620838894592 | 90.8546 | 0.00000158685 | 90 | 2.4276861076977241e-10,4.801714581503802e-14,-1.409576032285198e-09 | 0.24923650008289938,0.044450000000135353,0.044449999998941725
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.936Z | Extended Element | 5333577.1648994265,2184677.2993267165,360.3233412211593 | -179.145 | -0.118524 | 90 | 5.6384310058082838e-10,2.2233582043458774e-12,-4.331793275519329e-09 | 0.33972500084920976,0.12700000101465472,0.012700003724645866
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.959Z | Extended Element | 5333576.8782366822,2184679.6575097395,360.62818560649265 | -89.1424 | -1.43732 | -89.8814 | 1.8113368565580723e-09,-3.2862885745998938e-09,-3.2127329407938277e-09 | 2.0859791747489029,0.38099999997614115,0.085725035016868761
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.970Z | Line | 5333580.3726127381,2184689.7691811128,360.46490218324215 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.980Z | Line | 5333580.4113797611,2184687.1558033912,360.51246985202607 | 0 | 0 | 0 | 0,0,-0.12699972827078909 | 0.00026268512010574341,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:42.991Z | Line | 5333579.5180611489,2184687.307596908,360.51053233362785 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.001Z | Line | 5333579.5568281719,2184684.6942191864,360.55810000241183 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268418878316879,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.010Z | Line | 5333578.6634556865,2184684.8460119003,360.55610985728208 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.020Z | Line | 5333578.7024411159,2184682.2326374403,360.55475824871024 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.028Z | Line | 5333577.8088473575,2184682.3844268513,360.55269030714305 | 0 | 0 | 0 | 0,0,-0.12699972828636419 | 0.00026268605142831802,3.9180740714073181e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.039Z | Line | 5333577.8478167839,2184679.7710521491,360.50240235373616 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.92179936170578e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.046Z | Line | 5333576.9555176338,2184679.9228637619,360.50027407256476 | 0 | 0 | 0 | 0,0,-0.12699972828636419 | 0.00026268605142831802,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.054Z | Line | 5333576.99460408,2184677.3094879184,360.44998956843602 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.9222650229930878e-06,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.066Z | Extended Element | 5333603.247280024,2184690.110391024,360.34421639725917 | -179.145 | -0.118524 | 90 | 8.7315730747559027e-10,6.6571453149875396e-12,-5.3079781890296031e-09 | 0.33972500115946164,0.12700000101908879,0.012700003757512367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.082Z | Extended Element | 5333603.2406066833,2184689.716546536,360.26799026617562 | 0.855355 | 90.1185 | -0.00186478 | -5.5158239087305105e-12,-2.2784235609307757e-10,-2.2701074908759722e-09 | 0.27940000176141777,0.22859999825878441,0.15240000374615192
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.094Z | Extended Element | 5333603.1926421002,2184690.1400249018,360.41708352914549 | -89.1454 | -0.00000157979 | 90 | -7.9486220383451212e-10,-1.4256304470272596e-13,3.9877775387386905e-10 | 0.24923849918621382,0.044450000000003403,0.044450001446947593
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.107Z | Extended Element | 5333603.1927734427,2184690.1400268613,360.35358366499906 | -89.1454 | -0.00000157979 | 90 | 7.272375757150229e-10,-8.5712686948014039e-14,3.4810057267242733e-10 | 0.24923850000574244,0.044450000000060254,0.044450000817214473
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.124Z | Extended Element | 5333603.0786999958,2184689.7141344687,360.26765530441429 | 0.855355 | 90.1185 | -0.00076484 | 4.5366488343745459e-13,-5.8168325711704938e-10,-6.5192580223083496e-09 | 0.27940000169094459,0.22859999904007222,0.15239999903709592
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.138Z | Extended Element | 5333603.0054652924,2184690.1372328755,360.35319615007745 | -89.1454 | -0.00000157981 | 90 | -3.3947905597742078e-10,-1.329492071988625e-13,-8.9797604768682149e-10 | 0.24923849940688525,0.044450000000017316,0.044450000511797219
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.152Z | Extended Element | 5333603.0053339489,2184690.137230915,360.41669601412923 | -89.1454 | -0.00000157981 | 90 | -4.6190079538988016e-10,-1.3295961553971836e-13,-1.4509488228953149e-09 | 0.24923849951865384,0.044449999999960153,0.044449999029288936
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.168Z | Extended Element | 5333603.1878901776,2184687.4651038619,360.46465123378772 | 90.8546 | 0.00000158685 | 90 | -6.5834607210213392e-10,7.5803946453234516e-14,-2.3899932762028175e-09 | 0.24923649965016545,0.04445000000013502,0.044449999949640814
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.182Z | Extended Element | 5333603.1880215192,2184687.4651058251,360.4011513696413 | 90.8546 | 0.00000158685 | 90 | 1.4547749116466946e-10,1.0488485080450971e-13,-2.2606072777597852e-09 | 0.24923650021979871,0.044450000000192183,0.04444999922258383
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.194Z | Extended Element | 5333603.0005820263,2184687.4623098783,360.46426371879494 | 90.8546 | 0.00000158685 | 90 | -2.0069781947462673e-10,1.4565085248996468e-13,-1.4857177883798034e-09 | 0.24923649963943295,0.04445000000017886,0.044449999997473316
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.209Z | Extended Element | 5333603.0007133689,2184687.4623118402,360.40076385471951 | 90.8546 | 0.00000158685 | 90 | -3.3091629436654557e-10,8.8817841970012523e-14,-1.0891781018762536e-09 | 0.24923649974340492,0.044450000000122003,0.044450000394013006
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.226Z | Extended Element | 5333602.953344712,2184687.8857973707,360.31490774918382 | -179.145 | 89.8815 | -0.00186478 | -1.7706333205191882e-09,-5.1246487609013514e-10,8.2166112802539715e-10 | 0.27939999999630016,0.22859999877976597,0.15240000654011965
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.244Z | Extended Element | 5333603.1152514024,2184687.888209438,360.3152427109909 | -179.145 | 89.8815 | -0.00076484 | -1.6908946881555309e-09,3.3162966817101847e-10,-7.4505805969238281e-09 | 0.27939999999959614,0.22859999979796503,0.1523999989801697
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.257Z | Extended Element | 5333603.2862364631,2184687.484314716,360.39178406600104 | -179.145 | -0.118524 | 90 | -1.0238929530527282e-09,4.043688008860477e-13,-2.9348094135961112e-09 | 0.3397249992614737,0.12700000101283568,0.012700005121629727
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.271Z | Extended Element | 5333602.431684874,2184685.0227305111,360.43741421638674 | -179.145 | -0.118524 | 90 | 1.1791054972763907e-09,3.3033831627872565e-12,-3.4004707009038505e-09 | 0.33972500146447215,0.12700000101573469,0.012700004190307153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.286Z | Extended Element | 5333602.1460304381,2184685.000725673,360.5098938691807 | 90.8546 | 0.00000158685 | 90 | -3.3392272280607926e-10,-9.5059377036577075e-14,-9.3621300642499072e-10 | 0.24923649950620805,0.044449999999992273,0.044449999889709116
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.297Z | Extended Element | 5333602.1461617779,2184685.0007276349,360.44639400510528 | 90.8546 | 0.00000158685 | 90 | 1.5200896097411487e-12,-9.4715901788333667e-14,-1.4818737452404473e-09 | 0.24923650007584131,0.044449999999964476,0.04445000093243387
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.310Z | Extended Element | 5333602.3333385875,2184685.0035196571,360.51028138417337 | 90.8546 | 0.00000158685 | 90 | 6.0813235003287502e-10,-2.5212470999846914e-14,-1.9595952638340464e-10 | 0.24923650044826312,0.044450000000049117,0.044450001212558238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.324Z | Extended Element | 5333602.333469931,2184685.0035216203,360.446781520027 | 90.8546 | 0.00000158685 | 90 | 4.7791387514095618e-10,-8.2045481519799068e-14,-2.6351491128062676e-09 | 0.24923650055223509,0.04444999999999226,0.044449998190773013
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.340Z | Extended Element | 5333602.2606998133,2184685.4266252327,360.36087286137661 | -179.145 | 89.8815 | -0.00076484 | -1.690269410548062e-09,9.3424404323805277e-10,-7.4505805969238281e-09 | 0.27940000000022142,0.22860000026362631,0.15240000134303058
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.356Z | Extended Element | 5333602.0987931229,2184685.4242131654,360.36053789956793 | -179.145 | 89.8815 | -0.00186478 | -1.7662563911446938e-09,1.4071241394297829e-10,-1.9995644029435766e-10 | 0.27940000000067711,0.22860000099260486,0.15240000576924218
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.373Z | Extended Element | 5333602.3860550951,2184687.2549623311,360.31362041656291 | 0.855355 | 90.1185 | -0.00186478 | -2.9578700599941499e-12,-8.8101748119129297e-10,-8.9252513713056203e-10 | 0.27940000176397572,0.22859999831410469,0.1524000046774745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.389Z | Extended Element | 5333602.2241484066,2184687.2525502639,360.3132854548 | 0.855355 | 90.1185 | -0.00076484 | -2.5590363161853702e-12,1.1440088043546126e-09,-7.4505805969238281e-09 | 0.27940000168793189,0.22859999963058819,0.15239999857465686
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.404Z | Extended Element | 5333602.1507823588,2184687.6756467107,360.46232616451482 | -89.1454 | -0.00000157979 | 90 | 9.8584249097477539e-10,-8.5712686948014039e-14,7.1009750510220293e-10 | 0.24923850073272813,0.044450000000060254,0.044450001179211412
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.418Z | Extended Element | 5333602.1509137023,2184687.6756486711,360.39882630046304 | -89.1454 | -0.00000157979 | 90 | 8.7676801929781334e-10,-1.4255610580882205e-13,-6.0137581026076248e-10 | 0.24923850015527288,0.04445000000000341,0.044449999867738094
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.436Z | Extended Element | 5333602.3380905092,2184687.678440697,360.4627136795313 | -89.1454 | -0.00000157981 | 90 | -8.0213902187153963e-10,-1.8943180357666733e-14,-2.4442364902899083e-09 | 0.24923849964679634,0.044450000000074166,0.044449999533300436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.451Z | Extended Element | 5333602.3382218545,2184687.6784426565,360.39921381538494 | -89.1454 | -0.00000157981 | 90 | -6.7699781891583655e-10,-9.0382562545343603e-14,-6.6698243803009483e-10 | 0.24923849906936651,0.044449999999960146,0.044449999813255328
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.461Z | Extended Element | 5333602.3927284339,2184687.6488068188,360.38984654764488 | -179.145 | -0.118524 | 90 | 2.8946410259475946e-10,9.728034289067381e-13,-4.8423169017218638e-09 | 0.33972500057576843,0.12700000101340445,0.012700004223173654
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.476Z | Extended Element | 5333601.4789515315,2184682.5419379114,360.50693963047195 | 90.8546 | 0.00000158685 | 90 | -6.4721336623385639e-10,-1.3888890038060708e-13,-2.1578021661139424e-10 | 0.2492364989587271,0.044449999999935402,0.044450001187092386
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.491Z | Extended Element | 5333601.479082875,2184682.5419398742,360.44343976632553 | 90.8546 | 0.00000158685 | 90 | -5.4596088761016404e-10,-1.3888890038060708e-13,-1.7458513211499049e-09 | 0.24923649952836033,0.044449999999935402,0.044449999091360798
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.505Z | Extended Element | 5333601.2916433811,2184682.5391439269,360.50655211547917 | 90.8546 | 0.00000158685 | 90 | 2.7065721885932703e-10,-3.7872482927525652e-14,8.8080546675750604e-10 | 0.24923650034497843,0.04445000000002132,0.044450002363996571
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.520Z | Extended Element | 5333601.2917747246,2184682.5391458892,360.44305225140369 | 90.8546 | 0.00000158685 | 90 | 3.7734865232508241e-10,-9.4715901788333667e-14,-2.4443432521115138e-09 | 0.24923649998328912,0.044449999999964476,0.044449998392868867
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.537Z | Extended Element | 5333601.4063127572,2184682.965043487,360.35753110767507 | -179.145 | 89.8815 | -0.00076484 | -1.6936800295574983e-09,-3.7046063439127863e-10,-4.6566128730773926e-09 | 0.27939999999681081,0.22859999887280535,0.15240000141586166
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.554Z | Extended Element | 5333601.2444060678,2184682.9626314193,360.35719614586799 | -179.145 | 89.8815 | -0.00186478 | -1.7678479929950086e-09,-5.6562188266440216e-10,1.5544620035612411e-09 | 0.27939999999908549,0.22859999792100361,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.571Z | Extended Element | 5333601.5772978179,2184682.561148765,360.43407246268521 | -179.145 | -0.118524 | 90 | 1.382442112262032e-10,2.3938884610143282e-12,-3.4004707009038505e-09 | 0.33972500042361087,0.1270000010148252,0.012700004190307153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.588Z | Extended Element | 5333601.5314496318,2184684.7933773231,360.35919794021555 | 0.855355 | 90.1185 | -0.00186478 | -6.1411015161993987e-12,-6.0641422439111636e-10,-8.7300056073047472e-10 | 0.27940000176079249,0.22859999835303074,0.15240000297527445
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.606Z | Extended Element | 5333601.3695429442,2184684.7909652563,360.35886297845417 | 0.855355 | 90.1185 | -0.00076484 | -3.9232783688447626e-12,-8.5704265906372257e-10,-6.5192580223083496e-09 | 0.27940000168656765,0.22859999800773384,0.15239999802521831
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.621Z | Extended Element | 5333601.2961768964,2184685.2140617026,360.50790368816916 | -89.1454 | -0.00000157981 | 90 | -4.1698519637201059e-10,-1.893971091071478e-14,-2.1640426325908457e-09 | 0.2492384997977598,0.044450000000074166,0.044450000182492136
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.636Z | Extended Element | 5333601.2963082399,2184685.214063663,360.4444038241175 | -89.1454 | -0.00000157981 | 90 | -6.0373067656271928e-11,-1.3228654283103936e-13,2.4251226374283341e-10 | 0.24923849968599127,0.044449999999960806,0.04445000072275003
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.647Z | Extended Element | 5333601.4834850486,2184685.216855689,360.50829120318542 | -89.1454 | -0.00000157979 | 90 | 6.4979316372060225e-10,-1.4256304470272596e-13,-5.5082334873834959e-10 | 0.24923850039667877,0.044450000000003403,0.044450001432359589
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.660Z | Extended Element | 5333601.4836163912,2184685.2168576489,360.44479133903911 | -89.1454 | -0.00000157979 | 90 | 7.233794119265724e-11,-1.4222303890143451e-13,-1.545502004152155e-09 | 0.24923849981922358,0.044449999999946567,0.044449999858625105
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.671Z | Extended Element | 5333601.5381229725,2184685.1872218112,360.43542407129905 | -179.145 | -0.118524 | 90 | 3.9181700652488465e-10,-1.1304030689431585e-12,-5.7736394763373424e-09 | 0.33972500067812134,0.12700000101130124,0.012700003291851079
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.686Z | Extended Element | 5333600.6288767196,2184682.7552706399,360.50487165304656 | -89.1454 | -0.00000157981 | 90 | -1.0305153397283107e-09,-1.8980650384747833e-13,-1.7584594405595233e-09 | 0.2492384989500393,0.044449999999960479,0.044449999289541922
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.696Z | Extended Element | 5333600.4415685683,2184682.7524766535,360.50448413803008 | -89.1454 | -0.00000157979 | 90 | -1.765590451618948e-10,-1.4222303890143451e-13,1.1521299747574432e-09 | 0.24923849957032657,0.044449999999946567,0.044450002556257084
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.710Z | Extended Element | 5333600.44169991,2184682.752478614,360.44098427397824 | -89.1454 | -0.00000157979 | 90 | 6.4568905777662167e-10,-1.4222303890143451e-13,7.9557196594470803e-10 | 0.24923849992419395,0.044449999999946567,0.044450001264685866
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.727Z | Extended Element | 5333600.6290080622,2184682.7552725999,360.44137178890014 | -89.1454 | -0.00000157981 | 90 | 9.5183211312743765e-10,-1.3295961553971836e-13,4.0586395355646232e-11 | 0.24923850116657714,0.044449999999960153,0.044450000520824165
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.744Z | Extended Element | 5333600.6768413028,2184682.3317922745,360.35577839007652 | 0.855355 | 90.1185 | -0.00186478 | -8.5466356214425332e-13,-3.7098166205673522e-10,-8.2811266177706955e-10 | 0.27940000176607893,0.22859999896695612,0.1524000046774745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.759Z | Extended Element | 5333600.5149346152,2184682.3293802072,360.3554434283152 | 0.855355 | 90.1185 | -0.00076484 | -3.9801217877055706e-12,4.4551376476853477e-10,-6.5192580223083496e-09 | 0.2794000016865108,0.22859999893209315,0.15239999783755986
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.772Z | Extended Element | 5333600.6835146425,2184682.7256367621,360.43200452116002 | -179.145 | -0.118524 | 90 | 9.3188111107320592e-10,-1.640649483094222e-13,-6.2393007636450816e-09 | 0.33972500121818544,0.12700000101226758,0.012700003291851079
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.790Z | Extended Element | 5333600.5516884252,2184680.5034581949,360.30517521270093 | -179.145 | 89.8815 | -0.00076484 | -1.6912925643319809e-09,-7.8735035158317146e-10,-4.6566128730773926e-09 | 0.27939999999919818,0.22859999886664245,0.1524000002083053
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.807Z | Extended Element | 5333600.3897817349,2184680.5010461276,360.30484025089385 | -179.145 | 89.8815 | -0.00186478 | -1.7709174959801288e-09,1.6534174029914084e-10,-5.6305626827679589e-11 | 0.27939999999601584,0.22859999877976597,0.1524000046774745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.822Z | Extended Element | 5333600.4371503908,2184680.077560598,360.39069635642966 | 90.8546 | 0.00000158685 | 90 | -1.4136194992353524e-10,-8.1712414612411521e-14,-1.3456375631826223e-09 | 0.24923649946457851,0.044449999999992579,0.044450000137553541
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.836Z | Extended Element | 5333600.4370190501,2184680.0775586362,360.45419622050508 | 90.8546 | 0.00000158685 | 90 | 6.8598868252500722e-10,-8.1712414612411521e-14,-1.7240234483073547e-09 | 0.24923650029192915,0.044449999999992579,0.044449999113188671
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.851Z | Extended Element | 5333600.6243271995,2184680.0803526193,360.45458373549781 | 90.8546 | 0.00000158685 | 90 | 1.1623824680562223e-09,-3.7539416020138106e-14,8.8105234913316011e-10 | 0.24923650076832293,0.044450000000021653,0.044450001557627454
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.865Z | Extended Element | 5333600.6244585421,2184680.0803545825,360.39108387135138 | 90.8546 | 0.00000158685 | 90 | 3.2959290852119238e-10,-9.438283488094612e-14,-2.5079898366420217e-09 | 0.24923650087229487,0.044449999999964809,0.044449998975201271
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.877Z | Extended Element | 5333600.722673486,2184680.0995634734,360.38171656771112 | -179.145 | -0.118524 | 90 | 2.3541616609233433e-09,3.7581308066290403e-12,-2.469148126288372e-09 | 0.33972500263952826,0.12700000101618933,0.01270000465596844
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.902Z | Extended Element | 5333600.4678679882,2184680.3822009158,360.25335734304093 | 90.8543 | 1.43348 | 89.8814 | -7.0031269803617858e-10,-7.3896444519050419e-12,9.092302050150991e-10 | 2.0859791728264745,0.38100000002386664,0.085726460441946983
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.928Z | Extended Element | 5333603.031703339,2184687.7483494673,360.26539156415356 | 90.8485 | -1.35969 | 89.8814 | 2.2806467615472129e-10,-1.6615331333014183e-10,-1.455983627224492e-06 | 2.0859791722285776,0.39546210281036326,0.085726458880768269
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.954Z | Extended Element | 5333602.1771517536,2184685.286765263,360.31102171472838 | 90.8485 | -1.35969 | 89.8814 | -1.655422468465136e-10,-9.4360075308941305e-12,8.2928550138028356e-10 | 2.0859791725777375,0.38100000000936712,0.085726460750168446
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.977Z | Extended Element | 5333601.2907349952,2184684.9196600667,360.68893224001215 | -89.1453 | -0.0386396 | -89.8815 | 7.3019734703194672e-10,-1.9724666344700381e-11,-1.0125477400979577e-09 | 2.0859791725172738,0.38099999999404011,0.085725018754601479
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:43.991Z | Extended Element | 5333599.8301849198,2184680.2640736732,360.37958828658174 | -179.145 | -0.118524 | 90 | -2.0207952145346875e-09,-1.072219688628788e-13,-5.3079781890296039e-09 | 0.33972499826550917,0.12700000101232442,0.012700004223173654
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.004Z | Extended Element | 5333599.8301849198,2184680.2640736732,360.37958828658174 | -179.145 | -0.118524 | 90 | -2.0207952145346875e-09,-1.072219688628788e-13,-5.3079781890296039e-09 | 0.33972499826550917,0.12700000101232442,0.012700004223173654
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.018Z | Extended Element | 5333599.5883701881,2184680.2909155246,360.38856803939996 | -89.1454 | -0.00000157979 | 90 | 2.2829152457326529e-10,-1.9940646356353398e-13,-5.4709673596997632e-10 | 0.24923849950679638,0.04444999999994656,0.044450000501073103
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.032Z | Extended Element | 5333599.5882388437,2184680.2909135646,360.45206790345173 | -89.1454 | -0.00000157979 | 90 | 8.057467471012103e-10,-1.9907339665614643e-13,-2.0386680468775786e-09 | 0.24923850008425164,0.044449999999889717,0.044450000881276389
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.045Z | Extended Element | 5333599.775546995,2184680.2937075505,360.45245541846822 | -89.1454 | -0.00000157981 | 90 | 1.8328225048769298e-10,-1.9262369477246466e-14,-5.1787526697544273e-10 | 0.24923849992964658,0.044450000000073833,0.044450000891898003
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.060Z | Extended Element | 5333599.7756783394,2184680.2937095105,360.3889555543218 | -89.1454 | -0.00000157981 | 90 | -3.9414760344413935e-10,-7.6109257785006434e-14,-2.1149813671239581e-09 | 0.2492384993522167,0.04445000000001699,0.044449999862555573
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.077Z | Extended Element | 5333599.6616048915,2184679.8678171183,360.30302719373685 | 0.855355 | 90.1185 | -0.00076484 | -1.9905743720016744e-12,-7.0585343125983968e-11,-4.6566128730773926e-09 | 0.27940000168850027,0.22859999992965965,0.1524000028445637
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.093Z | Extended Element | 5333599.8235115791,2184679.8702291851,360.30336215549664 | 0.855355 | 90.1185 | -0.00186478 | -5.135752934037896e-13,-1.7468818058752333e-10,1.9297341780077915e-09 | 0.27940000176641988,0.2285999984062706,0.15240000560879707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.110Z | Extended Element | 5333599.6984757222,2184678.0418939646,360.2527624274008 | -179.145 | 89.8815 | -0.00076484 | -1.6908378724922457e-09,-2.7134647306858994e-10,-7.4505805969238281e-09 | 0.27939999999965304,0.22859999933230374,0.1523999985796422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.126Z | Extended Element | 5333599.5365690319,2184678.0394818974,360.25242746559218 | -179.145 | 89.8815 | -0.00186478 | -1.7668248392110897e-09,-3.1183972071247013e-11,1.2943040250679161e-09 | 0.27940000000010873,0.22859999877976597,0.15240000670056475
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.138Z | Extended Element | 5333599.5839376878,2184677.6159963682,360.33828357112947 | 90.8546 | 0.00000158685 | 90 | -4.2745779138542161e-10,-1.3888890038060708e-13,-3.6883259363351684e-09 | 0.24923649894429228,0.044449999999935416,0.04444999778922018
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.151Z | Extended Element | 5333599.5838063452,2184677.615994405,360.40178343520483 | 90.8546 | 0.00000158685 | 90 | 6.286442755243371e-10,-1.3888890038060708e-13,-1.2908979024617295e-09 | 0.24923650070296549,0.044449999999935416,0.044450000186648214
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.163Z | Extended Element | 5333599.7712458391,2184677.6187903532,360.33867108605119 | 90.8546 | 0.00000158685 | 90 | -4.1944472894961393e-10,1.8960527592426502e-14,-1.9586627458823003e-10 | 0.24923649942068604,0.044450000000078177,0.044450001281679835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.179Z | Extended Element | 5333599.7711144956,2184677.618788389,360.40217095019756 | 90.8546 | 0.00000158685 | 90 | 1.7643494998331732e-10,1.8970935933282362e-14,-1.4783651039462775e-09 | 0.24923649978237541,0.044450000000078163,0.044449999209500331
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.193Z | Extended Element | 5333599.869460782,2184677.6379992431,360.32930378241093 | -179.145 | -0.118524 | 90 | 9.0642128862033906e-10,5.1223725663326993e-12,-2.469148126288372e-09 | 0.33972500119178795,0.12700000101755374,0.012700005121629727
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.213Z | Extended Element | 5333599.5827979706,2184679.9961822662,360.63414818778762 | -89.1424 | -1.43732 | -89.8814 | -2.5304025541572628e-10,-3.2421212525353946e-09,9.5102040131855858e-10 | 2.0859791726799077,0.38100000002223522,0.08572503924369812
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.224Z | Line | 5333603.0771740945,2184690.1078536394,360.47086474449384 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.233Z | Line | 5333603.1159411175,2184687.4944759179,360.51843241327776 | 0 | 0 | 0 | 0,0,-0.12699972827078909 | 0.00026268512010574341,3.92179936170578e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.244Z | Line | 5333602.2226225054,2184687.6462694346,360.5164948948796 | 0 | 0 | 0 | 0,0,-0.12699972828636419 | 0.00026268698275089264,3.9185397326946259e-06,0
