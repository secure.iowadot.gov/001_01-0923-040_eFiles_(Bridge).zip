Properties of the parts of a building model (IFC4X3_ADD2), part 17 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.079Z | Extended Element | 5333583.9615303129,2184679.4615162299,361.03398210210298 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.091Z | Extended Element | 5333583.8472428015,2184679.4598114607,361.03401076374581 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.102Z | Extended Element | 5333583.7329552909,2184679.4581066919,361.03403942542201 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.121Z | Extended Element | 5333583.6186678056,2184679.4564019223,361.0339748708019 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.131Z | Extended Element | 5333583.5043803267,2184679.4546971535,361.03388256707626 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.143Z | Extended Element | 5333583.3900928516,2184679.4529923848,361.03379026333863 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.154Z | Extended Element | 5333583.2758053727,2184679.4512876156,361.03369795962379 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.164Z | Extended Element | 5333583.1615178967,2184679.4495828473,361.03360565588093 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.175Z | Extended Element | 5333583.0472304188,2184679.4478780781,361.03351335214523 | -179.145 | -0.0000235619 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.187Z | Extended Element | 5333582.9329429409,2184679.4461733093,361.03342104842824 | -179.145 | -0.0000367415 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.195Z | Extended Element | 5333582.8186554629,2184679.4444685401,361.03332874470431 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.207Z | Extended Element | 5333582.7043679859,2184679.44276377,361.03323644095286 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.218Z | Extended Element | 5333582.5900805099,2184679.4410590031,361.03314413723098 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.227Z | Extended Element | 5333582.475793032,2184679.4393542339,361.03305183350665 | -179.145 | -0.0000158147 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.234Z | Extended Element | 5333582.3615055522,2184679.4376494652,361.03295952976134 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.242Z | Extended Element | 5333582.2472180761,2184679.435944696,361.03286722604179 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.252Z | Extended Element | 5333582.1329305982,2184679.4342399272,361.03277492230865 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.261Z | Extended Element | 5333582.0186431231,2184679.4325351585,361.03268261857039 | -179.145 | -0.0000223839 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.271Z | Extended Element | 5333581.9043556442,2184679.4308303888,361.03259031482997 | -179.145 | -0.0000300245 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.280Z | Extended Element | 5333581.7900681663,2184679.429125621,361.03249801111724 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.291Z | Extended Element | 5333581.6757806893,2184679.4274208518,361.03240570738672 | -179.145 | -0.0000168369 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.302Z | Extended Element | 5333581.5614932124,2184679.4257160835,361.03231340366864 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.312Z | Extended Element | 5333581.4472057344,2184679.4240113148,361.03222109993663 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.324Z | Extended Element | 5333581.3329182575,2184679.4223065455,361.03212879618752 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.336Z | Extended Element | 5333581.2186307786,2184679.4206017763,361.03203649245967 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.345Z | Extended Element | 5333581.1043433025,2184679.4188970076,361.0319441887404 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.355Z | Extended Element | 5333580.9900558237,2184679.4171922384,361.03185188501271 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.367Z | Extended Element | 5333580.8757683486,2184679.4154874696,361.03175958126593 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.377Z | Extended Element | 5333580.7614808697,2184679.4137827009,361.03166727753927 | -179.145 | -0.0000234059 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.388Z | Extended Element | 5333580.6471933927,2184679.4120779317,361.03157497380619 | -179.145 | -0.0000224411 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.397Z | Extended Element | 5333580.5329059148,2184679.4103731634,361.031482670081 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.408Z | Extended Element | 5333580.4186184369,2184679.4086683942,361.03139036635588 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.420Z | Extended Element | 5333580.3043309599,2184679.4069636255,361.03129806262348 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.429Z | Extended Element | 5333580.1900434811,2184679.4052588567,361.03120575889227 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.440Z | Extended Element | 5333580.0757560022,2184679.403554087,361.03111345515663 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.451Z | Extended Element | 5333579.961468528,2184679.4018493188,361.03102115141127 | -179.145 | -0.0000300658 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.461Z | Extended Element | 5333579.847181051,2184679.4001445496,361.03092884770422 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.473Z | Extended Element | 5333579.7328935722,2184679.3984397808,361.03083654396448 | -179.145 | -0.0000168289 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.484Z | Extended Element | 5333579.6186060952,2184679.3967350121,361.03074424022935 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.495Z | Extended Element | 5333579.5043186173,2184679.3950302433,361.03065193650275 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.506Z | Extended Element | 5333579.3900311412,2184679.3933254741,361.03055963276921 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.518Z | Extended Element | 5333579.2757436642,2184679.3916207054,361.03046732903749 | -179.145 | -0.0000290102 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.527Z | Extended Element | 5333579.1614561863,2184679.3899159371,361.0303750253205 | -179.145 | -0.0000366428 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.535Z | Extended Element | 5333579.0471687075,2184679.3882111679,361.03028272158519 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.546Z | Extended Element | 5333578.9328812296,2184679.3865063991,361.03019041784904 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.557Z | Extended Element | 5333578.8185937526,2184679.3848016299,361.03009811412414 | -179.145 | -0.0000223917 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.568Z | Extended Element | 5333578.7043062756,2184679.3830968612,361.03000581039788 | -179.145 | -0.0000366428 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.577Z | Extended Element | 5333578.5900187995,2184679.381392092,361.02991350665815 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.586Z | Extended Element | 5333578.4757313197,2184679.3796873237,361.02982120293711 | -179.145 | -0.0000234059 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.595Z | Extended Element | 5333578.3614438437,2184679.3779825545,361.02972889919812 | -179.145 | -0.0000158147 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.607Z | Extended Element | 5333578.2471563667,2184679.3762777857,361.02963659548487 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.617Z | Extended Element | 5333578.1328688869,2184679.3745730161,361.02954429175423 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.628Z | Extended Element | 5333578.0185814109,2184679.3728682473,361.0294519880124 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.640Z | Extended Element | 5333577.904293933,2184679.3711634781,361.02935968428551 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.652Z | Extended Element | 5333577.790006456,2184679.3694587094,361.02926738054572 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.660Z | Extended Element | 5333577.675718978,2184679.3677539411,361.02917507681212 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.669Z | Extended Element | 5333577.5614315011,2184679.3660491719,361.02908277308717 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.678Z | Extended Element | 5333577.4471440231,2184679.3643444031,361.02899046935727 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.687Z | Extended Element | 5333577.3328565471,2184679.3626396339,361.02889816561918 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.696Z | Extended Element | 5333577.2185690682,2184679.3609348652,361.02880586189133 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.705Z | Extended Element | 5333577.1042815913,2184679.3592300969,361.02871355816086 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.716Z | Extended Element | 5333576.9899941143,2184679.3575253272,361.02862125443943 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.726Z | Extended Element | 5333576.8757066354,2184679.3558205594,361.02852895070259 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.736Z | Extended Element | 5333576.7614191584,2184679.3541157893,361.02843664697679 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.746Z | Extended Element | 5333576.6471316814,2184679.3524110215,361.02834434323864 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.756Z | Extended Element | 5333576.5328442054,2184679.3507062527,361.02825203952392 | -179.145 | -0.0000290596 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.766Z | Extended Element | 5333576.4185567256,2184679.3490014835,361.02815973577151 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.776Z | Extended Element | 5333576.3042692505,2184679.3472967143,361.02806743205952 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.789Z | Extended Element | 5333576.1899818098,2184679.3455919456,361.02794710946182 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.801Z | Extended Element | 5333576.075694493,2184679.3438871796,361.02773384076266 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.811Z | Extended Element | 5333575.9614071772,2184679.3421824132,361.02752057206106 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.820Z | Extended Element | 5333575.8471198613,2184679.3404776473,361.02730730335378 | -179.145 | -0.0000224411 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.831Z | Extended Element | 5333575.7328325463,2184679.3387728808,361.02709403464672 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.841Z | Extended Element | 5333575.6185452314,2184679.3370681149,361.02688076594922 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.851Z | Extended Element | 5333575.5042579137,2184679.335363348,361.02666749723375 | -179.145 | -0.000023554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.860Z | Extended Element | 5333575.3899705978,2184679.3336585816,361.02645422850316 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.870Z | Extended Element | 5333575.2756832838,2184679.3319538147,361.02624095981923 | -179.145 | -0.0000156587 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.879Z | Extended Element | 5333575.1613959689,2184679.3302490483,361.02602769111155 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.892Z | Extended Element | 5333575.0471086521,2184679.3285442819,361.02581442241342 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.903Z | Extended Element | 5333574.9328213371,2184679.3268395159,361.02560115369317 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.912Z | Extended Element | 5333574.8185340203,2184679.32513475,361.02538788498413 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.921Z | Extended Element | 5333574.7042467035,2184679.3234299836,361.02517461628508 | -179.145 | -0.0000290596 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.930Z | Extended Element | 5333574.5899593886,2184679.3217252167,361.02496134757968 | -179.145 | -0.0000224331 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.940Z | Extended Element | 5333574.4756720737,2184679.3200204503,361.02474807886 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.951Z | Extended Element | 5333574.3613847569,2184679.3183156834,361.02453481015061 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.961Z | Extended Element | 5333574.2470974401,2184679.316610917,361.0243215414564 | -179.145 | -0.0000235046 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.972Z | Extended Element | 5333574.1328101261,2184679.3149061515,361.02410827274792 | -179.145 | -0.0000158148 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.983Z | Extended Element | 5333574.0185228102,2184679.3132013846,361.02389500404712 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:44.992Z | Extended Element | 5333573.9042354934,2184679.3114966177,361.0236817353267 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.003Z | Extended Element | 5333573.7899481785,2184679.3097918513,361.02346846661953 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.013Z | Extended Element | 5333573.6756608626,2184679.3080870849,361.02325519791731 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.027Z | Extended Element | 5333573.5613735439,2184679.306382318,361.02304192919655 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.038Z | Extended Element | 5333573.4470862299,2184679.3046775521,361.02282866049649 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.048Z | Extended Element | 5333573.3327989141,2184679.3029727857,361.02261539178886 | -179.145 | -0.0000300165 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.060Z | Extended Element | 5333573.2185115991,2184679.3012680192,361.02240212308857 | -179.145 | -0.0000300165 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.068Z | Extended Element | 5333573.1042242814,2184679.2995632533,361.02218885439004 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.076Z | Extended Element | 5333572.9899369664,2184679.2978584869,361.02197558568372 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.085Z | Extended Element | 5333572.8756496515,2184679.29615372,361.0217623169633 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.095Z | Extended Element | 5333572.7613623366,2184679.2944489541,361.02154904825341 | -179.145 | -0.0000367988 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.105Z | Extended Element | 5333572.6470750198,2184679.2927441876,361.02133577955436 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.115Z | Extended Element | 5333572.5327877048,2184679.2910394208,361.02112251084532 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.125Z | Extended Element | 5333572.418500388,2184679.2893346543,361.02090924213309 | -179.145 | -0.0000235619 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.135Z | Extended Element | 5333572.3042130722,2184679.2876298884,361.02069597344149 | -179.145 | -0.0000367415 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.144Z | Extended Element | 5333572.1899257591,2184679.285925122,361.02048270471568 | -179.145 | -0.0000300658 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.155Z | Extended Element | 5333572.0756384414,2184679.2842203551,361.02026943600686 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.165Z | Extended Element | 5333571.9613511264,2184679.2825155891,361.0200561673139 | -179.145 | -0.000023554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.176Z | Extended Element | 5333571.8470638096,2184679.2808108218,361.01984289859655 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.185Z | Extended Element | 5333571.7327764956,2184679.2791060568,361.01962962988944 | -179.145 | -0.000015716 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.196Z | Extended Element | 5333571.618489176,2184679.2774012899,361.01941636118687 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.207Z | Extended Element | 5333571.504201863,2184679.2756965235,361.01920309248919 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.217Z | Extended Element | 5333571.3899145471,2184679.2739917566,361.0189898237598 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.228Z | Extended Element | 5333571.2756272312,2184679.2722869902,361.01877655506513 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.239Z | Extended Element | 5333571.1613399163,2184679.2705822238,361.01856328636825 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.248Z | Extended Element | 5333571.0470525986,2184679.2688774583,361.01835001764994 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.259Z | Extended Element | 5333570.9327652836,2184679.2671726909,361.01813674893577 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.268Z | Extended Element | 5333570.8184779696,2184679.2654679255,361.01792348023736 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.276Z | Extended Element | 5333570.70419065,2184679.2637631581,361.01771021152251 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.288Z | Extended Element | 5333570.589903336,2184679.2620583917,361.01749694281011 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.296Z | Extended Element | 5333570.4756160192,2184679.2603536258,361.01728367410499 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.307Z | Extended Element | 5333570.3613287052,2184679.2586488593,361.0170704054143 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.319Z | Extended Element | 5333570.2470413903,2184679.2569440925,361.01685713670588 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.328Z | Extended Element | 5333570.1327540725,2184679.255239326,361.01664386798853 | -179.145 | -0.0000168289 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.341Z | Extended Element | 5333570.0184667585,2184679.2535345596,361.01643059928671 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.349Z | Extended Element | 5333569.9041794408,2184679.2518297927,361.01621733057181 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.358Z | Extended Element | 5333569.7898921268,2184679.2501250268,361.01600406187362 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.367Z | Extended Element | 5333569.67560481,2184679.2484202608,361.01579079317395 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.376Z | Extended Element | 5333569.561317496,2184679.246715494,361.01557752446439 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.385Z | Extended Element | 5333569.4470301801,2184679.2450107276,361.01536425574858 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.395Z | Extended Element | 5333569.3327428633,2184679.2433059611,361.01515098705323 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.405Z | Extended Element | 5333569.2184555484,2184679.2416011947,361.0149377183381 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.415Z | Extended Element | 5333569.1041682325,2184679.2398964283,361.01472444962258 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.424Z | Extended Element | 5333568.9898809167,2184679.2381916619,361.01451118091933 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.434Z | Extended Element | 5333568.8755935999,2184679.2364868959,361.01429791220551 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.443Z | Extended Element | 5333568.761306284,2184679.2347821286,361.01408464349436 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.461Z | Extended Element | 5333568.6470191693,2184679.2330773659,361.01378758872505 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.471Z | Extended Element | 5333568.5327321421,2184679.2313726041,361.01345335599939 | -179.145 | -0.0000168862 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.480Z | Extended Element | 5333568.4184451168,2184679.2296678415,361.01311912324996 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.490Z | Extended Element | 5333568.3041580906,2184679.2279630797,361.01278489049383 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.502Z | Extended Element | 5333568.1898710635,2184679.2262583165,361.01245065775811 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.511Z | Extended Element | 5333568.075584041,2184679.2245535557,361.01211642501534 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.521Z | Extended Element | 5333567.9612970129,2184679.2228487935,361.01178219227137 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.530Z | Extended Element | 5333567.8470099857,2184679.2211440313,361.01144795952661 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.539Z | Extended Element | 5333567.7327229595,2184679.2194392681,361.01111372677764 | -179.145 | -0.0000167875 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.547Z | Extended Element | 5333567.6184359351,2184679.2177345068,361.01077949404822 | -179.145 | -0.0000366923 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.556Z | Extended Element | 5333567.504148908,2184679.2160297446,361.01044526130323 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.565Z | Extended Element | 5333567.3898618817,2184679.2143249828,361.01011102854693 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.576Z | Extended Element | 5333567.2755748574,2184679.2126202206,361.00977679581297 | -179.145 | -0.0000224332 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.588Z | Extended Element | 5333567.1612878311,2184679.2109154584,361.00944256307582 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.596Z | Extended Element | 5333567.0470008021,2184679.2092106962,361.00910833032265 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.607Z | Extended Element | 5333566.9327137768,2184679.2075059344,361.00877409758499 | -179.145 | -0.0000234059 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.617Z | Extended Element | 5333566.8184267525,2184679.2058011717,361.00843986484756 | -179.145 | -0.0000290022 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.628Z | Extended Element | 5333566.7041397262,2184679.2040964095,361.00810563209888 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.639Z | Extended Element | 5333566.5898527,2184679.2023916482,361.00777139936469 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.650Z | Extended Element | 5333566.4755656738,2184679.2006868855,361.00743716661225 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.658Z | Extended Element | 5333566.3612786485,2184679.1989821238,361.00710293386271 | -179.145 | -0.0000290022 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.667Z | Extended Element | 5333566.2469916204,2184679.1972773611,361.00676870114074 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.676Z | Extended Element | 5333566.1327045951,2184679.1955725993,361.00643446838075 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.685Z | Extended Element | 5333566.0184175689,2184679.1938678371,361.00610023564792 | -179.145 | -0.0000233565 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.695Z | Extended Element | 5333565.9041305436,2184679.1921630758,361.00576600290816 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.705Z | Extended Element | 5333565.7898435174,2184679.1904583126,361.00543177017397 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.714Z | Extended Element | 5333565.6755564911,2184679.1887535513,361.00509753742102 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.724Z | Extended Element | 5333565.5612694649,2184679.1870487891,361.00476330466887 | -179.145 | -0.0000289528 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.733Z | Extended Element | 5333565.4469824387,2184679.1853440264,361.00442907191808 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.743Z | Extended Element | 5333565.3326954115,2184679.1836392642,361.00409483919049 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.754Z | Extended Element | 5333565.2184083853,2184679.1819345024,361.00376060643367 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.763Z | Extended Element | 5333565.1041213619,2184679.1802297407,361.00342637370193 | -179.145 | -0.0000224331 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.773Z | Extended Element | 5333564.9898343338,2184679.1785249785,361.00309214096433 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.781Z | Extended Element | 5333564.8755473085,2184679.1768202162,361.0027579082215 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.792Z | Extended Element | 5333564.7612602822,2184679.1751154535,361.00242367547503 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.803Z | Extended Element | 5333564.6469732579,2184679.1734106927,361.0020894427347 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.812Z | Extended Element | 5333564.5326862307,2184679.17170593,361.00175520999625 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.819Z | Extended Element | 5333564.4183992036,2184679.1700011673,361.00142097723455 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.830Z | Extended Element | 5333564.3041121773,2184679.1682964051,361.00108674450053 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.838Z | Extended Element | 5333564.1898251511,2184679.1665916434,361.00075251176742 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.847Z | Extended Element | 5333564.0755381258,2184679.1648868811,361.00041827900691 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.858Z | Extended Element | 5333563.9612510996,2184679.1631821198,361.00008404627494 | -179.145 | -0.0000234139 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.866Z | Extended Element | 5333563.8469640724,2184679.1614773576,360.99974981352864 | -179.145 | -0.0000223424 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.877Z | Extended Element | 5333563.7326770471,2184679.1597725949,360.99941558079104 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.888Z | Extended Element | 5333563.61839002,2184679.1580678332,360.9990813480423 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.898Z | Extended Element | 5333563.5041029956,2184679.1563630709,360.99874711531595 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.906Z | Extended Element | 5333563.3898159694,2184679.1546583083,360.99841288256641 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.915Z | Extended Element | 5333563.2755289413,2184679.152953547,360.99807864982063 | -179.145 | -0.000029975 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.924Z | Extended Element | 5333563.161241916,2184679.1512487843,360.99774441706546 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.933Z | Extended Element | 5333563.0469548907,2184679.1495440216,360.99741018433593 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.943Z | Extended Element | 5333562.9326678645,2184679.1478392598,360.99707595158674 | -179.145 | -0.0000290102 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.954Z | Extended Element | 5333562.8183808392,2184679.1461344981,360.99674171885556 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
