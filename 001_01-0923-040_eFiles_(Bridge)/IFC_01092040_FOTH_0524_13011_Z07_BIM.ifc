Properties of the parts of a building model (IFC4X3_ADD2), part 5 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.249Z | Line String | 5333596.805775417,2184686.5781455222,0 | 0 | 0 | 0 | 0,0,0 | 0.17998073808848858,0.087217737454921007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.254Z | Line String | 5333596.9857561551,2184686.6653632596,0 | 0 | 0 | 0 | -0.053716958500444889,-0.0038063600659370422,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.260Z | Line String | 5333596.9857561551,2184686.6653632596,0 | 0 | 0 | 0 | -0.036273411475121975,-0.039802508894354105,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.265Z | Line String | 5333596.3677183986,2184685.393646834,0 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513596672564745,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.269Z | Line String | 5333596.4102032091,2184685.5160218813,0 | 0 | 0 | 0 | -0.08496962022036314,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.274Z | Line String | 5333596.1840493223,2184685.5945354789,0 | 0 | 0 | 0 | -0.084969622083008289,-0.24475009692832828,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.281Z | Line String | 5333596.4484259421,2184685.3656276856,0 | 0 | 0 | 0 | 0,-0.065593347884714603,0 | 0.18893785495311022,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.285Z | Line String | 5333596.6373637971,2184685.3000343377,0 | 0 | 0 | 0 | -0.040675128810107708,0,0 | 0,0.035292122513055801,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.289Z | Line String | 5333596.6373637971,2184685.3000343377,0 | 0 | 0 | 0 | -0.053793799132108688,-0.002495449036359787,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.296Z | Line String | 5333596.0011820402,2184684.3378599938,0 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513596672564745,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.301Z | Line String | 5333596.0436668526,2184684.4602350416,0 | 0 | 0 | 0 | -0.084969622083008289,-0.2447500959970057,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.305Z | Line String | 5333595.817512963,2184684.5387486387,0 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.311Z | Line String | 5333596.0818895847,2184684.3098408431,0 | 0 | 0 | 0 | 0,-0.065593346953392029,0 | 0.18893785402178764,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.316Z | Line String | 5333596.2708274387,2184684.2442474961,0 | 0 | 0 | 0 | -0.040675127878785133,0,0 | 0,0.035292122513055801,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.320Z | Line String | 5333596.2708274387,2184684.2442474961,0 | 0 | 0 | 0 | -0.053793798200786114,-0.002495449036359787,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.326Z | Line String | 5333595.6346456818,2184683.2820731513,0 | 0 | 0 | 0 | -0.22615388687700033,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.331Z | Line String | 5333595.6771304924,2184683.4044482,0 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009739398956,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.336Z | Line String | 5333595.4509766046,2184683.4829617962,0 | 0 | 0 | 0 | -0.084969621151685715,-0.2447500959970057,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.340Z | Line String | 5333595.7153532263,2184683.2540540025,0 | 0 | 0 | 0 | 0,-0.065593347884714603,0 | 0.18893785495311022,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.345Z | Line String | 5333595.9042910812,2184683.1884606546,0 | 0 | 0 | 0 | -0.040675128810107708,0,0 | 0,0.035292121581733227,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.351Z | Line String | 5333595.9042910812,2184683.1884606546,0 | 0 | 0 | 0 | -0.053793798200786114,-0.0024954481050372124,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.356Z | Line String | 5333595.2681093253,2184682.2262863098,0 | 0 | 0 | 0 | -0.22615388687700033,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.367Z | Line String | 5333595.3105941378,2184682.3486613575,0 | 0 | 0 | 0 | -0.084969623014330864,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.371Z | Line String | 5333595.0844402481,2184682.4271749547,0 | 0 | 0 | 0 | -0.084969621151685715,-0.2447500959970057,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.377Z | Line String | 5333595.3488168698,2184682.1982671618,0 | 0 | 0 | 0 | 0,-0.065593347884714603,0 | 0.18893785402178764,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.381Z | Line String | 5333595.5377547238,2184682.132673814,0 | 0 | 0 | 0 | -0.040675128810107708,0,0 | 0,0.035292122047394514,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.385Z | Line String | 5333595.5377547238,2184682.132673814,0 | 0 | 0 | 0 | -0.053793798200786114,-0.002495449036359787,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.389Z | Line String | 5333594.9015729669,2184681.1704994692,0 | 0 | 0 | 0 | -0.22615388967096806,0,0 | 0,0.078513596206903458,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.395Z | Line String | 5333594.9440577775,2184681.2928745169,0 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.400Z | Line String | 5333594.7179038897,2184681.3713881141,0 | 0 | 0 | 0 | -0.084969623014330864,-0.24475009739398956,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.404Z | Line String | 5333594.9822805123,2184681.1424803194,0 | 0 | 0 | 0 | 0,-0.065593347419053316,0 | 0.18893785309046507,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.410Z | Line String | 5333595.1712183654,2184681.0768869719,0 | 0 | 0 | 0 | -0.040675127878785133,0,0 | 0,0.035292122047394514,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.415Z | Line String | 5333595.1712183654,2184681.0768869719,0 | 0 | 0 | 0 | -0.053793798200786114,-0.0024954495020210743,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.420Z | Line String | 5333594.4741583914,2184680.0462532025,0 | 0 | 0 | 0 | -0.10439745057374239,0,0 | 0,0.21543244551867247,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.426Z | Line String | 5333594.5907319151,2184680.1027441323,0 | 0 | 0 | 0 | -0.23314704839140177,-0.11298185680061579,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.430Z | Line String | 5333594.4863344645,2184680.3181765769,0 | 0 | 0 | 0 | -0.23314704839140177,-0.11298185680061579,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.434Z | Line String | 5333594.5114147123,2184679.9693718217,0 | 0 | 0 | 0 | 0,-0.17998074041679502,0 | 0.087217737920582294,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.439Z | Line String | 5333594.5986324502,2184679.7893910813,0 | 0 | 0 | 0 | -0.0038063609972596169,0,0 | 0,0.053716958966106176,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.445Z | Line String | 5333594.5986324502,2184679.7893910813,0 | 0 | 0 | 0 | -0.039802508428692818,0,0 | 0,0.036273411475121975,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.449Z | Line String | 5333595.2861826178,2184686.8254536064,0 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388780832291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.454Z | Line String | 5333595.4085576655,2184686.7829687949,0 | 0 | 0 | 0 | -0.24475009739398956,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.458Z | Line String | 5333595.4870712627,2184687.0091226827,0 | 0 | 0 | 0 | -0.24475009739398956,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.464Z | Line String | 5333595.3927153628,2184687.1323150378,0 | 0 | 0 | 0 | 0,0,0 | 0.065593347884714603,0.18893785588443279,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.467Z | Line String | 5333595.4583087107,2184687.3212528937,0 | 0 | 0 | 0 | -0.035292121581733227,-0.040675129741430283,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.471Z | Line String | 5333595.4583087107,2184687.3212528937,0 | 0 | 0 | 0 | 0,-0.053793799132108688,0 | 0.002495449036359787,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.478Z | Line String | 5333594.9196462594,2184685.7696667654,0 | 0 | 0 | 0 | 0,0,0 | 0.078513596206903458,0.22615388734266162,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.483Z | Line String | 5333595.0420213081,2184685.7271819534,0 | 0 | 0 | 0 | -0.24475009739398956,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.487Z | Line String | 5333595.1205349043,2184685.9533358412,0 | 0 | 0 | 0 | -0.24475009739398956,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.493Z | Line String | 5333594.553109901,2184684.7138799233,0 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388873964548,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.497Z | Line String | 5333594.6754849497,2184684.6713951118,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.504Z | Line String | 5333594.7539985469,2184684.8975490006,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.509Z | Line String | 5333594.1865735436,2184683.6580930818,0 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388780832291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.514Z | Line String | 5333594.3089485914,2184683.6156082703,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.519Z | Line String | 5333594.3874621885,2184683.8417621586,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.524Z | Line String | 5333593.8200371861,2184682.6023062402,0 | 0 | 0 | 0 | 0,0,0 | 0.078513596206903458,0.22615388873964548,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.530Z | Line String | 5333593.9424122339,2184682.5598214287,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.536Z | Line String | 5333594.020925831,2184682.7859753175,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.540Z | Line String | 5333593.4535008278,2184681.5465193987,0 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388873964548,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.546Z | Line String | 5333593.5758758765,2184681.5040345876,0 | 0 | 0 | 0 | -0.24475009739398956,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.551Z | Line String | 5333593.6543894727,2184681.7301884759,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.555Z | Line String | 5333593.0869644703,2184680.4907325581,0 | 0 | 0 | 0 | 0,0,0 | 0.078513597138226032,0.22615388780832291,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.561Z | Line String | 5333593.209339519,2184680.4482477466,0 | 0 | 0 | 0 | -0.24475009646266699,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.566Z | Line String | 5333593.2878531162,2184680.6744016344,0 | 0 | 0 | 0 | -0.24475009739398956,0,0 | 0,0.084969622083008289,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.570Z | Line String | 5333593.0589453205,2184680.4100250136,0 | 0 | 0 | 0 | -0.065593346953392029,-0.18893785495311022,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.576Z | Line String | 5333592.9933519736,2184680.2210871587,0 | 0 | 0 | 0 | 0,0,0 | 0.035292122513055801,0.040675128810107708,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.580Z | Line String | 5333592.9933519736,2184680.2210871587,0 | 0 | 0 | 0 | -0.0024954481050372124,0,0 | 0,0.053793798200786114,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.585Z | Line String | 5333594.0818997445,2184687.2806544034,0 | 0 | 0 | 0 | -0.10439745057374239,0,0 | 0,0.21543244458734989,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.589Z | Line String | 5333594.1984732701,2184687.3371453313,0 | 0 | 0 | 0 | -0.23314705025404692,-0.11298185680061579,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.595Z | Line String | 5333594.0940758185,2184687.5525777759,0 | 0 | 0 | 0 | -0.23314704932272434,-0.11298185680061579,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.599Z | Line String | 5333593.940245972,2184687.5729682297,0 | 0 | 0 | 0 | -0.087217736057937145,0,0 | 0,0.17998073995113373,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.603Z | Line String | 5333593.853028236,2184687.7529489696,0 | 0 | 0 | 0 | 0,-0.053716959431767464,0 | 0.003806358203291893,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.610Z | Line String | 5333593.853028236,2184687.7529489696,0 | 0 | 0 | 0 | 0,-0.0362734105437994,0 | 0.039802507497370243,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.615Z | Line String | 5333593.7762416042,2184686.293326986,0 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.619Z | Line String | 5333593.8187264148,2184686.4157020347,0 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.623Z | Line String | 5333593.592572527,2184686.4942156319,0 | 0 | 0 | 0 | -0.084969621151685715,-0.2447500959970057,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.630Z | Line String | 5333593.4693801729,2184686.399859732,0 | 0 | 0 | 0 | -0.18893785309046507,0,0 | 0,0.065593346953392029,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.634Z | Line String | 5333593.2804423198,2184686.465453079,0 | 0 | 0 | 0 | 0,-0.035292122513055801,0 | 0.040675127878785133,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.638Z | Line String | 5333593.2804423198,2184686.465453079,0 | 0 | 0 | 0 | 0,0,0 | 0.053793797269463539,0.002495449036359787,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.646Z | Line String | 5333593.4097052477,2184685.2375401449,0 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513596206903458,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.651Z | Line String | 5333593.4521900602,2184685.3599151927,0 | 0 | 0 | 0 | -0.084969623014330864,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.655Z | Line String | 5333593.2260361705,2184685.4384287898,0 | 0 | 0 | 0 | -0.08496962022036314,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.660Z | Line String | 5333593.1028438155,2184685.3440728909,0 | 0 | 0 | 0 | -0.18893785309046507,0,0 | 0,0.065593346487730742,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.665Z | Line String | 5333592.9139059624,2184685.4096662374,0 | 0 | 0 | 0 | 0,-0.035292122513055801,0 | 0.040675127878785133,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.670Z | Line String | 5333592.9139059624,2184685.4096662374,0 | 0 | 0 | 0 | 0,0,0 | 0.053793796338140965,0.0024954495020210743,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.676Z | Line String | 5333593.0431688894,2184684.1817533029,0 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.680Z | Line String | 5333593.0856537009,2184684.3041283516,0 | 0 | 0 | 0 | -0.084969622083008289,-0.24475009739398956,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.684Z | Line String | 5333592.8594998121,2184684.3826419478,0 | 0 | 0 | 0 | -0.08496962022036314,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.689Z | Line String | 5333592.6766325328,2184683.1259664609,0 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.695Z | Line String | 5333592.7191173462,2184683.2483415087,0 | 0 | 0 | 0 | -0.084969623945653439,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.699Z | Line String | 5333592.4929634556,2184683.3268551058,0 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009646266699,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.703Z | Line String | 5333592.3100961745,2184682.0701796194,0 | 0 | 0 | 0 | -0.22615388780832291,0,0 | 0,0.078513597138226032,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.707Z | Line String | 5333592.3525809869,2184682.1925546685,0 | 0 | 0 | 0 | -0.084969623014330864,-0.24475009692832828,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.713Z | Line String | 5333592.1264270972,2184682.2710682652,0 | 0 | 0 | 0 | -0.084969621151685715,-0.24475009739398956,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.717Z | Line String | 5333591.7227666499,2184681.0014508516,0 | 0 | 0 | 0 | 0,0,0 | 0.21543244458734989,0.10439745103940368,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.721Z | Line String | 5333591.7792575778,2184680.884877326,0 | 0 | 0 | 0 | -0.11298185586929321,0,0 | 0,0.23314704932272434,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.727Z | Line String | 5333591.9946900234,2184680.989274777,0 | 0 | 0 | 0 | -0.11298185680061579,0,0 | 0,0.23314704885706306,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.733Z | Line String | 5333591.6458852682,2184680.9641945306,0 | 0 | 0 | 0 | -0.17998073901981115,-0.087217738851904869,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.738Z | Line String | 5333591.4659045292,2184680.8769767918,0 | 0 | 0 | 0 | 0,0,0 | 0.053716959431767464,0.0038063600659370422,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.744Z | Line String | 5333591.4659045292,2184680.8769767918,0 | 0 | 0 | 0 | 0,0,0 | 0.036273411475121975,0.039802508428692818,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.907Z | Line | 5333560.637260315,2184690.4083544938,361.92737492088395 | 0 | 0 | 0 | 0,0,-1.4434996165497296 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.917Z | Line | 5333570.5860718619,2184690.5567559144,361.93360369636616 | 0 | 0 | 0 | 0,0,-1.4434996165497296 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.926Z | Line | 5333580.5348834088,2184690.7051573349,361.93983247184838 | 0 | 0 | 0 | 0,0,-1.4434996165497296 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.935Z | Line | 5333590.4836949557,2184690.8535587555,361.94606124733065 | 0 | 0 | 0 | 0,0,-1.4434996165497296 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:16.945Z | Line | 5333600.4325065026,2184691.0019601765,361.95229002281286 | 0 | 0 | 0 | 0,0,-1.4434996165497296 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.017Z | Line | 5333549.6069179149,2184683.1056121401,361.0981187394018 | 0 | 0 | 0 | -4.0230341255664825e-05,-5.9977173805236816e-07,0 | 0,0,0.0091439297737565539
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.028Z | Line | 5333548.63391014,2184683.0910982722,361.09383693796127 | 0 | 0 | 0 | -4.022940993309021e-05,-5.9977173805236816e-07,0 | 0,0,0.0091439297737565539
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.069Z | Smart Solid | 5333545.4946628744,2184683.0442716987,361.08002280298325 | 0 | 0 | 0 | 0.79804232406890252,-7.1777953410759556,-0.39918720734435287 | 65.578088614038748,8.1679195507166771,0.10885921968501579
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.080Z | Line | 5333551.1806945056,2184675.9908790994,360.97922684902426 | 0 | 0 | 0 | 0,0,-0.25400050800180907 | 0,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.121Z | Extended Element | 5333546.2927051978,2184675.8664763584,360.68083559563894 | 0 | 0 | 0 | 6.2858918070674008e-10,-3.0323743516191826e-10,1.5876189252139739e-14 | 64.780046290598435,15.345714891489395,0.50804642702938452
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.168Z | Circle | 5333551.7074383833,2184690.0672425055,361.70214248742275 | 0 | 0 | 0 | 1.5079967762249118e-10,-0.01587326615797045,-0.0079375158736675125 | 0.00023677371263511394,-2.2603509688967627e-10,0.0079375158763959966
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.176Z | Circle | 5333551.7055260045,2184690.1954481751,361.70214248745202 | 0 | 0 | 0 | -7.8052289699298734e-10,-0.01587326615797045,-0.0079375158736675125 | 0.00023677278131253933,-2.2603509688967627e-10,0.0079375158763959966
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.185Z | Circle | 5333551.7062953301,2184690.1438725591,361.87146938606151 | 0 | 0 | 0 | 4.5125534311031643e-10,-0.01587834559718054,-0.0079400558787475154 | 0.00023684978063056694,-2.2014695968963771e-10,0.0079400558814759995
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.196Z | Circle | 5333551.7079285188,2184690.0343839433,361.53280542892486 | 0 | 0 | 0 | -4.8006723150516208e-10,-0.015878345131519252,-0.0079400558787475154 | 0.00023684884930799232,2.4551432761810155e-10,0.0079400558814759995
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.205Z | Circle | 5333551.7055260036,2184690.1954481741,361.53280542920635 | 0 | 0 | 0 | -7.8052289699298734e-10,-0.01587326615797045,-0.0079375158736675125 | 0.00023677278131253933,-2.2603509688967627e-10,0.0079375158763959966
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.215Z | Circle | 5333551.7057537865,2184690.1801777594,361.36346837030334 | 0 | 0 | 0 | -4.8006723150516208e-10,-0.01587834559718054,-0.0079400558787475154 | 0.00023684884930799232,-2.2014695968963771e-10,0.0079400558814759995
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.223Z | Circle | 5333551.7082733912,2184690.0112637961,361.36346836998979 | 0 | 0 | 0 | -4.8006723150516208e-10,-0.015878345131519252,-0.0079400558787475154 | 0.00023684884930799232,2.4551432761810155e-10,0.0079400558814759995
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.235Z | Circle | 5333551.7055259673,2184690.1954507143,361.08406781146721 | 0 | 0 | 0 | -4.8006723150516208e-10,-0.01587834559718054,-0.0079400558787475154 | 0.00023684884930799232,-2.2014695968963771e-10,0.0079400558814759995
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.245Z | Circle | 5333551.7092274604,2184689.9473031065,361.084067811593 | 0 | 0 | 0 | -4.8006723150516208e-10,-0.01587834559718054,-0.0079400558787475154 | 0.00023684884930799232,-2.2014695968963771e-10,0.0079400558814759995
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.255Z | Complex Chain | 5333551.7214414263,2184689.1284805452,360.78094514192077 | 0 | 0 | 0 | -0.016038166359066963,0,-2.9179547667013139e-11 | 0,1.0751963462680578,0.60814426353058504
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.265Z | Complex Chain | 5333551.7077487335,2184690.0464367084,361.13742118954104 | 0 | 0 | 0 | -0.002345474436879158,-0.12496765035573093,-0.12955353065302688 | 0.0018640794983427042,0.15724018309265375,0.75151077485430862
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.275Z | Circle | 5333610.3309141099,2184691.0183465271,361.90817322615118 | 0 | 0 | 0 | -4.8006723147805703e-10,-0.015878345131519249,-0.0079400558787475137 | 0.00023684884930799227,2.4551432588337807e-10,0.0079400558814759978
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.285Z | Complex Chain | 5333610.3323675133,2184690.9209106769,361.17412502963072 | 0 | 0 | 0 | -0.0023454752473911237,-0.12496765035573093,-0.12955353065308373 | 0.0018640785670201295,0.1572401828838445,0.75151077485425177
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.296Z | Circle | 5333610.3301447835,2184691.0699221431,361.73884632754169 | 0 | 0 | 0 | 1.5079967762249118e-10,-0.015873265692309162,-0.0079375158736675125 | 0.00023677371263511394,2.3962619041806299e-10,0.0079375158763959966
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.304Z | Circle | 5333610.3320571631,2184690.9417164735,361.73884632751242 | 0 | 0 | 0 | -7.8052289699298734e-10,-0.015873265692309162,-0.0079375158736675125 | 0.00023677278131253933,2.3962619041806299e-10,0.0079375158763959966
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.316Z | Circle | 5333610.3301447826,2184691.0699221422,361.56950926929596 | 0 | 0 | 0 | 1.5079967762249118e-10,-0.015873265692309162,-0.0079375158736675125 | 0.00023677371263511394,2.3962619041806299e-10,0.0079375158763959966
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.324Z | Circle | 5333610.3325472977,2184690.9088579118,361.56950926901453 | 0 | 0 | 0 | 4.5125534313742149e-10,-0.015878345131519249,-0.0079400558787475137 | 0.00023684978063056688,2.4551432588337807e-10,0.0079400558814759978
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.335Z | Circle | 5333610.3303725654,2184691.0546517274,361.40017221039301 | 0 | 0 | 0 | 4.5125534313742149e-10,-0.015878345131519249,-0.0079400558788043571 | 0.00023684978063056688,2.4551432588337807e-10,0.0079400558814191544
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.345Z | Complex Chain | 5333610.3460602062,2184690.0029545138,360.81764898201044 | 0 | 0 | 0 | -0.016038166471413977,0,-2.9179554605907043e-11 | 0,1.0751963458023965,0.60814426353058504
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.353Z | Circle | 5333610.3328921702,2184690.8857377646,361.40017221007946 | 0 | 0 | 0 | 4.5125534313742149e-10,-0.015878345131519249,-0.0079400558787475137 | 0.00023684978063056688,2.4551432588337807e-10,0.0079400558814759978
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.365Z | Circle | 5333610.3301447462,2184691.0699246828,361.12077165155688 | 0 | 0 | 0 | 4.5125534313742149e-10,-0.015878345597180536,-0.0079400558787475137 | 0.00023684978063056688,-2.2014696142436119e-10,0.0079400558814759978
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.374Z | Circle | 5333610.3338462394,2184690.8217770751,361.12077165168267 | 0 | 0 | 0 | 4.5125534313742149e-10,-0.015878345597180536,-0.0079400558787475137 | 0.00023684978063056688,-2.2014696142436119e-10,0.0079400558814759978
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.386Z | Line | 5333610.3310325341,2184691.0104073547,361.91611328203265 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.396Z | Line | 5333610.3309141099,2184691.0183465271,361.90817322615118 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.405Z | Line | 5333610.3302631704,2184691.0619855104,361.74678384341803 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.415Z | Line | 5333610.3301447835,2184691.0699221431,361.73884632754169 | 0 | 0 | 0 | 0,-0.015873265452682972,0 | 0.00023677293211221695,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.424Z | Line | 5333610.3321755491,2184690.9337798408,361.74678384338881 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.434Z | Line | 5333610.3320571631,2184690.9417164735,361.73884632751242 | 0 | 0 | 0 | 0,-0.015873265452682972,0 | 0.00023677293211221695,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.445Z | Line | 5333610.3302631695,2184691.0619855095,361.57744678517236 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.454Z | Line | 5333610.3301447826,2184691.0699221422,361.56950926929596 | 0 | 0 | 0 | 0,-0.015873265452682972,0 | 0.00023677293211221695,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.464Z | Line | 5333610.3326657228,2184690.9009187394,361.57744932489601 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.473Z | Line | 5333610.3325472977,2184690.9088579118,361.56950926901453 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.485Z | Line | 5333610.3304909905,2184691.046712555,361.40811226627443 | 0 | 0 | 0 | 0,0,-0.015880111760168347 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.495Z | Line | 5333610.3303725654,2184691.0546517274,361.40017221039301 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.6716406864579767e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.505Z | Line | 5333610.3330105953,2184690.8777985922,361.40811226596094 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.515Z | Line | 5333610.3328921702,2184690.8857377646,361.40017221007946 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.524Z | Line | 5333610.3302631713,2184691.0619855099,361.12871170743836 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.535Z | Line | 5333610.3301447462,2184691.0699246828,361.12077165155688 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.544Z | Line | 5333610.3339646645,2184690.8138379022,361.12871170756415 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.554Z | Line | 5333610.3338462394,2184690.8217770751,361.12077165168267 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.565Z | Line | 5333551.7064137552,2184690.1359333862,361.87940944194298 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.573Z | Line | 5333551.7062953301,2184690.1438725591,361.87146938606151 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.584Z | Line | 5333551.7056443905,2184690.1875115419,361.71008000332841 | 0 | 0 | 0 | 0,0,-0.015875031750056223 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.595Z | Line | 5333551.7055260045,2184690.1954481751,361.70214248745202 | 0 | 0 | 0 | 0,-0.015873265918344259,0 | 0.00023677293211221695,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.603Z | Line | 5333551.7075567702,2184690.0593058723,361.71008000329914 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.616Z | Line | 5333551.7074383833,2184690.0672425055,361.70214248742275 | 0 | 0 | 0 | 0,-0.015873265918344259,0 | 0.00023677293211221695,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.623Z | Line | 5333551.7056443896,2184690.1875115409,361.54074294508268 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.633Z | Line | 5333551.7055260036,2184690.1954481741,361.53280542920635 | 0 | 0 | 0 | 0,-0.015873265918344259,0 | 0.00023677293211221695,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.642Z | Line | 5333551.7080469429,2184690.0264447709,361.54074548480634 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.653Z | Line | 5333551.7079285188,2184690.0343839433,361.53280542892486 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.662Z | Line | 5333551.7058722107,2184690.1722385865,361.37140842618481 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.670Z | Line | 5333551.7057537865,2184690.1801777594,361.36346837030334 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.678Z | Line | 5333551.7083918154,2184690.0033246237,361.37140842587127 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.686Z | Line | 5333551.7082733912,2184690.0112637961,361.36346836998979 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.698Z | Line | 5333551.7056443915,2184690.1875115414,361.09200786734868 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.705Z | Line | 5333551.7055259673,2184690.1954507143,361.08406781146721 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.715Z | Line | 5333551.7093458846,2184689.9393639336,361.09200786747448 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.723Z | Line | 5333551.7092274604,2184689.9473031065,361.084067811593 | 0 | 0 | 0 | 0,-0.015878345351666212,0 | 0.00023684930056333542,0,2.7284841053187847e-12
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.734Z | Line String | 5333551.7063243445,2184690.1419275119,361.88861851184254 | 0 | 0 | 0 | 0,0,0 | 58.624618698842824,0.87447921745479107,0.080237169900101435
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.744Z | Line String | 5333551.7071286086,2184690.0880099162,361.38908940379963 | 0 | 0 | 0 | 0,0,0 | 58.624613883905113,0.87447389494627714,0.080237169922042995
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.755Z | Line String | 5333550.6905247411,2184690.1207798785,361.86699897867851 | 0 | 0 | 0 | 0,0,0 | 60.656396810896695,0.90478097973391414,0.084707579085716134
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.765Z | Line String | 5333550.6897553764,2184690.1723580337,361.69767208001252 | 0 | 0 | 0 | 0,0,0 | 60.656396810896695,0.90478097973391414,0.084707579085716134
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.778Z | Line String | 5333550.691667757,2184690.0441523665,361.69767207917505 | 0 | 0 | 0 | 0,0,0 | 60.656396811828017,0.90478097880259156,0.08470757906803783
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.786Z | Line String | 5333550.6897553783,2184690.1723580356,361.52833501955007 | 0 | 0 | 0 | 0,0,0 | 60.656396810896695,0.90478097926825285,0.08470757907684856
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.797Z | Line String | 5333550.6897553792,2184690.172358036,361.07959740248299 | 0 | 0 | 0 | 0,0,0 | 60.656396810896695,0.90478097926825285,0.084707579062182958
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.805Z | Circle | 5333547.0345425699,2184676.0602962486,361.84999172162566 | 0 | 0 | 0 | -0.00023684974113980076,2.1955789443472984e-10,-0.0079400558787475154 | -4.9074610927691761e-10,0.015878345597769607,0.0079400558814759995
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.817Z | Line | 5333547.0344241448,2184676.0682354216,361.85793177750713 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.825Z | Line | 5333547.0345425708,2184676.0602962486,361.84999172162566 | 0 | 0 | 0 | -0.00023685023188591003,0,0 | 0,0.015878344886004925,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.836Z | Circle | 5333547.0353118991,2184676.0087206326,361.68066482301617 | 0 | 0 | 0 | -0.00023677274183440614,2.2544622418907423e-10,-0.0079375158736675125 | 7.4104476381457469e-10,0.015873266158559322,0.0079375158763959966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.846Z | Line | 5333547.0351935131,2184676.0166572658,361.68860233889257 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.854Z | Line | 5333547.0353118991,2184676.0087206326,361.68066482301617 | 0 | 0 | 0 | -0.00023677386343479156,0,0 | 0,0.015873265452682972,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.866Z | Circle | 5333547.0333995195,2184676.1369263022,361.68066482298696 | 0 | 0 | 0 | -0.00023677367315698075,-2.4021506311866503e-10,-0.0079375158736675125 | -1.9027781080090383e-10,0.015873265692898035,0.0079375158763959966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.874Z | Line | 5333547.0332811326,2184676.1448629345,361.68860233886335 | 0 | 0 | 0 | 0,0,-0.015875031750056223 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.885Z | Line | 5333547.0333995204,2184676.1369263018,361.68066482298696 | 0 | 0 | 0 | -0.00023677479475736618,0,0 | 0,0.015873265918344259,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.896Z | Circle | 5333547.0329093849,2184676.1697848639,361.51132776448901 | 0 | 0 | 0 | -0.00023684880981722614,-2.4610339287300942e-10,-0.0079400558787475154 | 4.405764653385609e-10,0.015878345132108319,0.0079400558814759995
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.906Z | Line | 5333547.0327909607,2184676.1777240364,361.51926782037049 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.916Z | Line | 5333547.032909384,2184676.1697848644,361.51132776448901 | 0 | 0 | 0 | -0.0002368483692407608,0,0 | 0,0.015878344886004925,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.925Z | Circle | 5333547.0353118973,2184676.0087206336,361.5113277647705 | 0 | 0 | 0 | -0.00023677274183440614,2.2544622418907423e-10,-0.0079375158736675125 | 7.4104476381457469e-10,0.015873266158559322,0.0079375158763959966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.935Z | Line | 5333547.0351935113,2184676.0166572668,361.51926528064689 | 0 | 0 | 0 | 0,0,-0.015875031750056223 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.946Z | Line | 5333547.0353118982,2184676.0087206336,361.5113277647705 | 0 | 0 | 0 | -0.00023677386343479156,0,0 | 0,0.015873265452682972,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.955Z | Circle | 5333547.0350841191,2184676.0239910483,361.34199070586749 | 0 | 0 | 0 | -0.00023684880981722614,2.1955789443472984e-10,-0.0079400558787475154 | 4.405764653385609e-10,0.015878345597769607,0.0079400558814759995
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.966Z | Line | 5333547.0349656949,2184676.0319302212,361.34993076174896 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.974Z | Line | 5333547.0350841191,2184676.0239910483,361.34199070586749 | 0 | 0 | 0 | -0.00023685023188591003,0,0 | 0,0.015878345351666212,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.986Z | Circle | 5333547.0325645143,2184676.1929050111,361.341990705554 | 0 | 0 | 0 | -0.00023684880981722614,2.1955789443472984e-10,-0.0079400558787475154 | 4.405764653385609e-10,0.015878345597769607,0.0079400558814759995
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:17.997Z | Line | 5333547.0324460901,2184676.200844184,361.34993076143547 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.006Z | Line | 5333547.0325645143,2184676.1929050107,361.341990705554 | 0 | 0 | 0 | -0.00023684930056333542,0,0 | 0,0.015878345817327499,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.017Z | Circle | 5333547.0353119383,2184676.0087180934,361.06259014703136 | 0 | 0 | 0 | -0.00023684880981722614,2.1955789443472984e-10,-0.0079400558787475154 | 4.405764653385609e-10,0.015878345597769607,0.0079400558814759995
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.026Z | Line | 5333547.0351935141,2184676.0166572663,361.07053020291283 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.035Z | Line | 5333547.0353119383,2184676.0087180929,361.06259014703136 | 0 | 0 | 0 | -0.00023685023188591003,0,0 | 0,0.015878345817327499,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.046Z | Circle | 5333547.0316104442,2184676.2568657007,361.06259014715715 | 0 | 0 | 0 | -0.00023684880981722614,2.1955789443472984e-10,-0.0079400558787475154 | 4.405764653385609e-10,0.015878345597769607,0.0079400558814759995
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.053Z | Line | 5333547.03149202,2184676.2648048736,361.07053020303863 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.064Z | Line | 5333547.0316104442,2184676.2568657007,361.06259014715715 | 0 | 0 | 0 | -0.0002368483692407608,0,0 | 0,0.015878345817327499,2.7284841053187847e-12
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.074Z | Complex Chain | 5333547.0330891702,2184676.1577320988,361.11594352510525 | 0 | 0 | 0 | -0.0018640801533182675,-0.15724018335457227,-0.12955353065308373 | 0.0023454725742340088,0.12496765082551434,0.75151077485425177
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.087Z | Complex Chain | 5333547.019396483,2184677.075688262,360.75946747748498 | 0 | 0 | 0 | 0,-1.0751963462680578,-2.921751729445532e-11 | 0.01603815967580894,0,0.60814426353058504
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.102Z | Circle | 5333605.659161347,2184676.9347702153,361.92361564342661 | 0 | 0 | 0 | -0.00023684880981722611,2.1955789616945331e-10,-0.0079400558788043571 | 4.4057646531145585e-10,0.015878345597769603,0.0079400558814191544
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.110Z | Line | 5333605.6590429228,2184676.9427093887,361.93155569930803 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.119Z | Line | 5333605.659161347,2184676.9347702158,361.92361564342661 | 0 | 0 | 0 | -0.00023684930056333542,0,0 | 0,0.015878345817327499,2.6716406864579767e-12
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.128Z | Complex Chain | 5333605.6577079473,2184677.0322060664,361.18956744690615 | 0 | 0 | 0 | -0.0018640801533182675,-0.15724018335457227,-0.12955353065308373 | 0.0023454725742340088,0.12496765035985305,0.75151077485425177
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.136Z | Circle | 5333605.6599306762,2184676.8831946002,361.75428874481713 | 0 | 0 | 0 | -0.00023677367315698075,-2.4021506311866503e-10,-0.0079375158736675125 | -1.9027781080090383e-10,0.015873265692898035,0.0079375158763959966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.145Z | Line | 5333605.6598122893,2184676.8911312325,361.76222626069347 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.155Z | Line | 5333605.6599306772,2184676.8831945998,361.75428874481713 | 0 | 0 | 0 | -0.00023677479475736618,0,0 | 0,0.015873265918344259,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.165Z | Circle | 5333605.6580182957,2184677.0114002689,361.75428874478786 | 0 | 0 | 0 | -0.00023677274183440614,-2.4021506311866503e-10,-0.0079375158736675125 | 7.4104476381457469e-10,0.015873265692898035,0.0079375158763959966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.174Z | Line | 5333605.6578999097,2184677.0193369021,361.76222626066425 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.184Z | Line | 5333605.6580182966,2184677.0114002689,361.75428874478786 | 0 | 0 | 0 | -0.00023677386343479156,0,0 | 0,0.015873265918344259,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.192Z | Circle | 5333605.6599306753,2184676.8831946012,361.5849516865714 | 0 | 0 | 0 | -0.00023677367315698075,-2.4021506311866503e-10,-0.0079375158736675125 | -1.9027781080090383e-10,0.015873265692898035,0.0079375158763959966
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.203Z | Line | 5333605.6598122884,2184676.8911312334,361.59288920244779 | 0 | 0 | 0 | 0,0,-0.01587503174999938 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.214Z | Line | 5333605.6599306762,2184676.8831946007,361.5849516865714 | 0 | 0 | 0 | -0.00023677479475736618,0,0 | 0,0.015873265918344259,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.222Z | Circle | 5333605.657528162,2184677.0442588311,361.58495168628997 | 0 | 0 | 0 | -0.00023684974113980073,2.1955789616945331e-10,-0.0079400558787475137 | -4.9074610930402267e-10,0.015878345597769603,0.0079400558814759978
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.233Z | Line | 5333605.6574097369,2184677.052198004,361.59289174217139 | 0 | 0 | 0 | 0,0,-0.015880111760168347 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.242Z | Line | 5333605.6575281629,2184677.0442588311,361.58495168628997 | 0 | 0 | 0 | -0.00023685023188591003,0,0 | 0,0.015878345351666212,2.6716406864579767e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.253Z | Circle | 5333605.6597028961,2184676.8984650159,361.41561462766839 | 0 | 0 | 0 | -0.00023684974113980073,2.1955789616945331e-10,-0.0079400558787475137 | -4.9074610930402267e-10,0.015878345597769603,0.0079400558814759978
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.263Z | Line | 5333605.659584471,2184676.9064041888,361.42355468354987 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.271Z | Line | 5333605.6597028971,2184676.8984650155,361.41561462766839 | 0 | 0 | 0 | -0.00023684930056333542,0,0 | 0,0.015878345351666212,2.7284841053187847e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.282Z | Circle | 5333605.6571832923,2184677.0673789778,361.4156146273549 | 0 | 0 | 0 | -0.00023684974113980073,2.1955789616945331e-10,-0.0079400558787475137 | -4.9074610930402267e-10,0.015878345597769603,0.0079400558814759978
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.290Z | Line | 5333605.6570648672,2184677.0753181512,361.42355468323638 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.300Z | Line | 5333605.6571832923,2184677.0673789782,361.4156146273549 | 0 | 0 | 0 | -0.00023685023188591003,0,0 | 0,0.015878345817327499,2.7284841053187847e-12
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.309Z | Complex Chain | 5333605.6440152591,2184677.9501622291,360.83309139928588 | 0 | 0 | 0 | 0,-1.0751963461175518,-2.9179554605907043e-11 | 0.016038161538454089,0,0.60814426353058504
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.320Z | Circle | 5333605.6599307153,2184676.883192061,361.13621406883232 | 0 | 0 | 0 | -0.00023684974113980073,-2.4610339113828594e-10,-0.0079400558788043571 | -4.9074610930402267e-10,0.015878345132108316,0.0079400558814191544
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.331Z | Line | 5333605.6598122902,2184676.891131233,361.14415412471374 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.340Z | Line | 5333605.6599307153,2184676.8831920605,361.13621406883232 | 0 | 0 | 0 | -0.0002368483692407608,0,0 | 0,0.015878345351666212,2.6716406864579767e-12
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.350Z | Circle | 5333605.6562292231,2184677.1313396688,361.13621406895811 | 0 | 0 | 0 | -0.00023684974113980073,-2.4610339113828594e-10,-0.0079400558787475137 | -4.9074610930402267e-10,0.015878345132108316,0.0079400558814759978
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.359Z | Line | 5333605.656110798,2184677.1392788407,361.14415412483959 | 0 | 0 | 0 | 0,0,-0.015880111760225191 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.370Z | Line | 5333605.6562292222,2184677.1313396683,361.13621406895811 | 0 | 0 | 0 | -0.00023684930056333542,0,0 | 0,0.015878345351666212,2.7284841053187847e-12
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.380Z | Line String | 5333546.0185351269,2184676.0530819162,361.84552131295692 | 0 | 0 | 0 | 0,0,0 | 60.656396808102727,0.90478097926825285,0.10618524350462621
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.388Z | Line String | 5333546.0173921138,2184676.1297094286,361.6761944148202 | 0 | 0 | 0 | 0,0,0 | 60.656396807171404,0.90478097926825285,0.10618524374370963
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.399Z | Line String | 5333546.0193044934,2184676.00150376,361.67619441411904 | 0 | 0 | 0 | 0,0,0 | 60.656396808102727,0.90478097880259156,0.10618524374956451
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.408Z | Line String | 5333546.0193044925,2184676.0015037614,361.50685735573506 | 0 | 0 | 0 | 0,0,0 | 60.656396808102727,0.90478097880259156,0.10618524375246352
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.418Z | Line String | 5333546.019076677,2184676.0167767177,361.33752029397135 | 0 | 0 | 0 | 0,0,0 | 60.656396808102727,0.90478097926825285,0.1061852437513835
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.429Z | Line String | 5333546.0193044916,2184676.0015037586,361.05811973831896 | 0 | 0 | 0 | 0,0,0 | 60.65639680903405,0.90478097880259156,0.1061852437690618
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.439Z | Line String | 5333547.034513562,2184676.0622413019,361.86714084160644 | 0 | 0 | 0 | 0,0,0 | 58.62464477494359,0.87447435595095158,0.10171483480570487
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.450Z | Line String | 5333547.0337092988,2184676.1161588919,361.36761173874106 | 0 | 0 | 0 | 0,0,0 | 58.624647247605026,0.87447439273819327,0.10171483481116184
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.466Z | Extended Element | 5333551.7031307705,2184689.8421467305,360.98126059926625 | 0 | 0 | 0 | -7.5363216969076552e-11,5.0126569561825818e-13,2.5147852550366778e-14 | 58.633473037241245,1.3086408196630059,1.0474624560453547
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.495Z | Extended Element | 5333551.9125787588,2184690.2067672228,361.00877933248626 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.506Z | Extended Element | 5333552.2173425164,2184690.2113132318,361.01012044218629 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.524Z | Extended Element | 5333552.5221062712,2184690.2158592395,361.01146155188621 | 0.854588 | 1.40057e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.534Z | Extended Element | 5333552.826870027,2184690.2204052475,361.01280266158591 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.543Z | Extended Element | 5333553.1316337818,2184690.2249512547,361.01414377128577 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.554Z | Extended Element | 5333553.4363975376,2184690.2294972623,361.01548488098564 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.564Z | Extended Element | 5333553.7411612943,2184690.2340432699,361.01682599068539 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.574Z | Extended Element | 5333554.0459250519,2184690.2385892789,361.0181671003852 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.586Z | Extended Element | 5333554.3506888067,2184690.2431352856,361.01950821008501 | 0.854588 | 7.574e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.603Z | Extended Element | 5333554.6554526621,2184690.2476812955,361.02082642748792 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.615Z | Extended Element | 5333554.960216525,2184690.2522273045,361.02214322905638 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.624Z | Extended Element | 5333555.2649803841,2184690.2567733149,361.02346003062479 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.641Z | Extended Element | 5333555.5697443038,2184690.2613193244,361.02476326529296 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.652Z | Extended Element | 5333555.8745084079,2184690.2658653371,361.02602294707918 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.662Z | Extended Element | 5333556.1792725101,2184690.2704113494,361.02728262886524 | 0.854588 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.674Z | Extended Element | 5333556.4840366133,2184690.2749573626,361.02854231065146 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.685Z | Extended Element | 5333556.7888007155,2184690.2795033758,361.02980199243757 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.705Z | Extended Element | 5333557.0935648829,2184690.2840493894,361.03104609037996 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.713Z | Extended Element | 5333557.3983292505,2184690.2885954059,361.03224014878748 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.722Z | Extended Element | 5333557.7030936191,2184690.2931414228,361.03343420719506 | 0.854589 | 2.02045e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.732Z | Extended Element | 5333558.0078579849,2184690.2976874397,361.03462826560269 | 0.854589 | 2.01579e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.741Z | Extended Element | 5333558.3126223516,2184690.3022334571,361.03582232401027 | 0.854589 | 2.64499e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.758Z | Extended Element | 5333558.6173867788,2184690.306779475,361.03700080105278 | 0.854589 | 1.39591e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.767Z | Extended Element | 5333558.9221513942,2184690.3113254947,361.03812923591687 | 0.854588 | 7.66716e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.776Z | Extended Element | 5333559.2269160142,2184690.3158715158,361.0392576707809 | 0.854589 | 2.01113e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.786Z | Extended Element | 5333559.5316806305,2184690.320417536,361.04038610564493 | 0.854589 | 1.39125e-07 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:18.797Z | Extended Element | 5333559.8364452468,2184690.3249635566,361.04151454050896 | 0.854588 | 7.62058e-08 | 90 | -0.01322509866272197,-0.0046776627865965379,-0.013175197458835495 | 0.013225100754717351,0.89426148814406747,0.29485438999380198
