Properties of the parts of a building model (IFC4X3_ADD2), part 24 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.974Z | Extended Element | 5333596.8985669166,2184681.3622005628,360.9722061372708 | -89.1454 | 0.000119121 | -0.0962788 | -0.0093042258108621614,-1.6323983933797017e-10,-0.0093042252189032264 | 0.0093042263022111125,10.922230530471756,0.025205147309834027
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.986Z | Extended Element | 5333598.0071498193,2184681.3787367707,360.9862440305991 | -89.1454 | -0.0000255733 | 179.904 | -0.0093038165733094428,-6.1837485174970765e-10,-0.0079375000010668412 | 0.0093038261458498316,10.368548385909701,0.031039894586417979
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.998Z | Extended Element | 5333588.1947065396,2184681.2323694867,360.9966803611909 | -89.1454 | -0.000379179 | 179.99 | -0.0093052185422956932,1.1560723641658004e-10,-0.0079375000008534268 | 0.0093051360002694792,10.922208951080204,0.030340442927574526
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.011Z | Extended Element | 5333578.3822583044,2184681.0860021291,360.99331074722369 | -89.1454 | 0.000128491 | -179.936 | -0.0093038306223585197,-5.4836140106006172e-10,-0.0079375000022171328 | 0.0093038049855036671,10.553524580331111,0.03076112028765985
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.022Z | Extended Element | 5333568.5698237326,2184680.9396349746,360.97655817751695 | -89.1454 | 0.0000703723 | -179.85 | -0.009303881023978772,-6.5567663948354499e-12,-0.0079375000010632711 | 0.0093039784945367823,9.8840476902472574,0.029847872483618785
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.032Z | Extended Element | 5333547.8367159953,2184680.6303696292,360.89917002765844 | -89.1454 | 179.999 | -0.2521 | -0.0079375108082500034,5.589366947777468e-10,-0.007937500001224191 | 0.007937500159004636,10.922025435536678,0.0092039704646796044
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.088Z | Extended Element | 5333596.7965821298,2184681.0684403889,360.9665178946787 | -89.1454 | 0.000100312 | -0.0962788 | -0.0093042261691160637,-4.3227132118683397e-10,-0.0093042252550174336 | 0.0093042263046958038,10.922230651320808,0.025205147124797374
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.099Z | Extended Element | 5333597.9051649356,2184681.0849765879,360.98055578816775 | -89.1454 | 0.0000856011 | 179.904 | -0.0093038642483309394,5.2717829718468356e-10,-0.0079375000036123015 | 0.0093038098462436911,10.262193312176047,0.031200185218628895
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.111Z | Extended Element | 5333588.0927214082,2184680.9386093011,360.99083182786654 | -89.1454 | 0.0000706219 | 179.99 | -0.0093052179509156268,4.7510385819948452e-10,-0.0079375000010161907 | 0.0093050976484728796,10.922208861796797,0.030477835379726283
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.124Z | Extended Element | 5333578.2802731404,2184680.7922419435,360.98732482131334 | -89.1454 | 0.0000769953 | -179.936 | -0.0093038387085824098,7.4861625980716738e-10,-0.0079375000029044789 | 0.0093038115158560839,10.447169308382795,0.030921411082390562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.134Z | Extended Element | 5333568.4678387698,2184680.6458747918,360.97041196077942 | -89.1454 | 0.000110851 | -179.85 | -0.0093040109789515463,-1.9118562293488305e-10,-0.0079375000015347776 | 0.00930386857643614,9.7776923185855971,0.029985263437932369
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.148Z | Extended Element | 5333547.7347315969,2184680.3366094548,360.89283510869359 | -89.1454 | 180 | -0.2521 | -0.0079375037020732384,4.4288175182897907e-10,-0.0079375000001654164 | 0.0079375003516435321,10.922025447818644,0.0091526587424086495
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.197Z | Extended Element | 5333599.0567896888,2184680.8099158849,360.95737044337295 | 90.8546 | 0.0000483262 | 0.0839427 | -0.0093042252489397778,-8.5597764228321687,-0.0093042252116840966 | 0.0093042256784094807,2.265581756136922,0.025205147020665449
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.207Z | Extended Element | 5333597.8031803919,2184680.7912164121,360.97510822252167 | -89.1454 | -0.0000663953 | 179.916 | -0.0093038707845854544,2.1867618824843071e-10,-0.0079375000011937188 | 0.0093039256515556681,10.155837796394183,0.029496775539469465
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.218Z | Extended Element | 5333587.9907362768,2184680.6448491151,360.9850061255097 | -89.1454 | -0.000320043 | 179.99 | -0.0093050756401693371,1.2370780788213587e-10,-0.0079375000000000018 | 0.0093051655032730992,10.922208773705318,0.030615227842919059
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.229Z | Extended Element | 5333578.1782879746,2184680.4984817579,360.9813617263697 | -89.1454 | -0.00000340055 | -179.936 | -0.009303817801329663,-1.8151294795985248e-10,-0.0079375000021716276 | 0.0093038286698707701,10.340814034204607,0.031081702214192895
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.240Z | Extended Element | 5333568.365853806,2184680.3521146094,360.96428857500723 | -89.1454 | -0.0000389647 | -179.85 | -0.0093051378776683839,-1.6116172849323454e-10,-0.0079375000014910106 | 0.0093051050176872728,10.922208927810987,0.030376178995713841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.250Z | Extended Element | 5333547.6327472031,2184680.0428492804,360.88652302070551 | -89.1454 | 180 | -0.2521 | -0.0079375098453398178,-8.723950451211176e-10,-0.0079374999998863237 | 0.0079374999298219111,10.922025457947219,0.0091013470294174972
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.302Z | Extended Element | 5333607.5136161717,2184680.6438231766,360.94576710837185 | -89.1454 | -0.0000446603 | 179.829 | -0.0093038114299371505,-1.4702446430924188e-11,-0.0079375000020411434 | 0.0093038407183914183,10.71900175175513,0.030568061312557498
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.312Z | Extended Element | 5333597.7011954738,2184680.4974562298,360.96941991272581 | -89.1454 | -0.0000748302 | 179.916 | -0.0093038711991031801,-2.3716983935187698e-10,-0.0079375000003410658 | 0.0093039048890064379,10.049482720102125,0.029634167907100807
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.324Z | Extended Element | 5333587.8887511482,2184680.3510889313,360.97918042347436 | -89.1454 | -0.0000806561 | 179.99 | -0.0093038170280857879,-5.4543967261369534e-11,-0.0079375000010184545 | 0.0093040415181051897,10.903965253737173,0.030232960898579343
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.332Z | Extended Element | 5333578.0763025256,2184680.2047215682,360.97563340260734 | -89.1454 | -0.0000721379 | -179.924 | -0.0093038706811194322,7.9717167727092725e-10,-0.0079375000009512236 | 0.0093039143090703127,10.234458328975832,0.029395215081471922
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.343Z | Extended Element | 5333568.2638688479,2184680.0583544266,360.95816518956553 | -89.1454 | -0.0000105423 | -179.85 | -0.0093051024346046812,1.3571455067840992e-10,-0.0079375000006821229 | 0.0093052241656319274,10.922208840367556,0.030513570278787476
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.354Z | Extended Element | 5333547.5307628056,2184679.7490891069,360.88021093301739 | -89.1454 | 180 | -0.2521 | -0.0079375042179171511,-3.8998732563921845e-11,-0.0079375000009527363 | 0.0079374998357398911,10.92202547308599,0.0090500353050043704
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.406Z | Extended Element | 5333607.2709368942,2184679.9447995108,360.93262374950928 | -89.1454 | -0.000124681 | 179.83 | -0.0093038077045492669,1.696034177559489e-10,-0.0079375000046585306 | 0.0093038657210077168,10.465922484474579,0.030893123683527365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.417Z | Extended Element | 5333597.4585150536,2184679.7984325471,360.95588416542341 | -89.1454 | -0.000161094 | 179.916 | -0.0093038949527942845,-1.2309976634817203e-10,-0.0079375000001874231 | 0.009303886027033418,9.7964031980844908,0.029961103263101731
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.429Z | Extended Element | 5333587.6460702028,2184679.6520652389,360.96531774149884 | -89.1454 | 0.00014569 | 179.99 | -0.0093038496085717376,-2.0353516101181841e-10,-0.0079375000001136869 | 0.0093038038713592081,10.6508854730083,0.030614385639519671
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.442Z | Extended Element | 5333577.8336215429,2184679.5056978762,360.96138929589694 | -89.1454 | -0.0000330365 | -179.924 | -0.0093038722767116323,1.4817610766822109e-10,-0.0079375000018302357 | 0.0093039478859830421,9.9813782864424336,0.029722149071421906
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.455Z | Extended Element | 5333568.0211882489,2184679.3593307408,360.94359414837157 | -89.1454 | 0.0000669149 | -179.85 | -0.0093038405135864328,-1.8784343531112466e-12,-0.0079375000011805245 | 0.009303812172175829,10.835916457955955,0.030335515079185454
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.465Z | Extended Element | 5333547.2880835254,2184679.0500654401,360.86519086109899 | -89.1454 | 179.999 | -0.2521 | -0.0079375073691361694,-2.7816973526754913e-10,-0.0079375000017390777 | 0.0079375002608060088,10.922023874520558,0.0087078194418469899
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.520Z | Extended Element | 5333607.1689524977,2184679.6510393363,360.9270957291281 | -89.1454 | 0.00010657 | 179.83 | -0.0093038822121689502,-2.0414327018771765e-10,-0.0079374999994884093 | 0.0093038117848228182,10.359567578017234,0.03105341440826228
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.530Z | Extended Element | 5333597.3565301914,2184679.5046723653,360.95019585551978 | -89.1454 | -0.000126358 | 179.916 | -0.0093050956971799468,-1.5556415368609293e-10,-0.0079375000006821194 | 0.009305228126243039,10.922208946992219,0.030352035236314509
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.542Z | Extended Element | 5333587.5440851152,2184679.3583050547,360.95949203943189 | -89.1454 | 0.000101821 | 179.99 | -0.0093038275257354974,8.0808775133498881e-10,-0.0079375000014081081 | 0.0093038288232737947,10.5445303419183,0.030774676615069326
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.555Z | Extended Element | 5333577.7316364339,2184679.2119376911,360.95540330256154 | -89.1454 | -0.0000897278 | -179.924 | -0.0093038692231582447,-8.9553411228334328e-10,-0.0079375000006118579 | 0.0093038852200269875,9.8750230426686834,0.029859541606134781
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.567Z | Extended Element | 5333567.9192033038,2184679.065570558,360.937470762945 | -89.1454 | 0.000156412 | -179.85 | -0.0093039005754603516,3.9029302009000425e-10,-0.0079375000014210873 | 0.0093038073752306633,10.729561104038945,0.03049580504842294
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.580Z | Extended Element | 5333547.1860991297,2184678.7563052662,360.85887877340264 | -89.1454 | 179.999 | -0.2521 | -0.0079375080207325505,7.7225257469888461e-11,-0.0079375000014510894 | 0.0079375000915721909,10.922023878690663,0.0086794061761838841
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.635Z | Extended Element | 5333598.5081540411,2184679.2296116743,360.92676976632833 | 90.8546 | 0.000142947 | 0.0839428 | -0.0093042255721955142,-8.5597765768604077,-0.0093042250816614287 | 0.009304225337104231,1.6934365387274681,0.025205147112083832
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.648Z | Extended Element | 5333597.2545453254,2184679.2109121843,360.94450754463224 | -89.1454 | -0.0000251667 | 179.916 | -0.0093051007013731004,2.7675130872815609e-10,-0.0079375000005902623 | 0.0093053088458339046,10.922208855868501,0.030489427426695678
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.660Z | Extended Element | 5333587.4421000229,2184679.0645448701,360.95366633637872 | -89.1454 | -0.000377075 | 179.99 | -0.0093037807289395452,-2.1609988959464961e-11,-0.0079375000014054713 | 0.0093039688648787772,10.438175207078411,0.030934968140183886
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.673Z | Extended Element | 5333577.6296513239,2184678.918177506,360.9494173082374 | -89.1454 | -0.000087735 | -179.924 | -0.0093038713347788418,-8.6963471699527331e-11,-0.0079375000019826242 | 0.0093045077257507443,9.7686677959802406,0.029996935566794124
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.684Z | Extended Element | 5333567.817218353,2184678.7718103761,360.93134737651894 | -89.1454 | 0.0000769832 | -179.85 | -0.0093038695923580977,3.3963603076407879e-11,-0.0079375000012373697 | 0.0093038115201547755,10.623205744605219,0.030656095380488056
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.696Z | Extended Element | 5333547.0841147322,2184678.4625450913,360.8525666847101 | -89.1454 | 180 | -0.2521 | -0.007937502417766161,-9.0121522918763695e-10,-0.0079375000043768913 | 0.0079375004437870073,10.922023881526895,0.0086509929035819676
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.750Z | Extended Element | 5333598.4061690634,2184678.9358514636,360.92108145650468 | 90.8546 | 0.0000432012 | 0.0839427 | -0.0093042258836272141,-8.5597769256973972,-0.0093042252184953444 | 0.0093042259877760929,1.5870814068360097,0.025205147520910708
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.762Z | Extended Element | 5333597.1525604613,2184678.9171520029,360.93881923464886 | -89.1454 | 0.0000342332 | 179.916 | -0.0093051071384294432,-8.0100443985525131e-10,-0.0079375000014736651 | 0.0093052068467560523,10.922208768008227,0.030626819647005026
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.775Z | Extended Element | 5333587.3401149334,2184678.7707846859,360.94784063423185 | -89.1454 | 0.000144529 | 179.99 | -0.009303871167130523,1.1037504238811831e-10,-0.0079375000000000036 | 0.0093038030199387896,10.331820075105963,0.03109525947289116
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.785Z | Extended Element | 5333577.5276662176,2184678.6244173218,360.94343131482077 | -89.1454 | -0.000090774 | -179.924 | -0.0093051019789147371,1.936898885889347e-10,-0.0079375000012326842 | 0.009305111377643005,10.922208922512628,0.030387860463186075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.797Z | Extended Element | 5333567.7152334051,2184678.4780501928,360.92522399100966 | -89.1454 | 0.0000859249 | -179.85 | -0.0093038909354518067,-6.6043205867660308e-10,-0.0079375000041650191 | 0.0093038109233041909,10.516850390558139,0.030816385000043571
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.808Z | Extended Element | 5333546.9821303366,2184678.1687849173,360.84625459692768 | -89.1454 | 180 | -0.2521 | -0.0079375030144769407,4.1424718861605635e-10,-0.00793750000093227 | 0.0079374998470650489,10.922023886657055,0.0086225796299000367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.856Z | Extended Element | 5333598.3041840885,2184678.6420912636,360.91539314639431 | 90.8546 | -0.0000186772 | 0.0839428 | -0.0093042255880385841,-8.5597772698101089,-0.009304225126851022 | 0.0093042257316164612,1.4807262739392884,0.025205147049449622
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.865Z | Extended Element | 5333597.0505755963,2184678.6233918215,360.93313092437404 | -89.1454 | -0.0000692718 | 179.916 | -0.0093041635193335907,8.1790907377082929e-10,-0.0079374999994884145 | 0.0093038476953994469,10.894986035163084,0.030338335251617513
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.875Z | Extended Element | 5333587.2381298635,2184678.4770245003,360.94216682108521 | -89.1454 | 0.000032579 | 179.998 | -0.0093038557906245656,-2.8772631107355594e-10,-0.0079375000012242829 | 0.0093038879067946605,10.225464706107349,0.030049563027315797
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.885Z | Extended Element | 5333577.4256811114,2184678.3306571371,360.93744532111396 | -89.1454 | -0.000148581 | -179.924 | -0.0093051398307770344,1.8321084173024184e-10,-0.00793750000120492 | 0.0093051145066066626,10.922208833809314,0.030525252492483369
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.896Z | Extended Element | 5333567.61324846,2184678.1842900114,360.91910060520649 | -89.1454 | 0.0000994113 | -179.85 | -0.0093038805145849463,1.9445592183638476e-10,-0.0079375000001869391 | 0.0093038097296184088,10.410495036149022,0.030976674591934514
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.906Z | Extended Element | 5333546.8801459381,2184677.8750247434,360.83994250885246 | -89.1454 | 179.999 | -0.2521 | -0.0079375056519767617,6.0785345786661686e-10,-0.0079375000008719485 | 0.0079375003143052954,10.922023892572719,0.008594166360284582
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.957Z | Extended Element | 5333598.2021991098,2184678.3483311827,360.90973471312543 | 90.8546 | 0.000351013 | 0.0839427 | -0.0093042259046050724,-8.5597776124155995,-0.0093042252071921135 | 0.0093042250600516054,1.3743711406471442,0.025205147339433895
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.967Z | Extended Element | 5333596.9485907312,2184678.3296316406,360.92747249093964 | -89.1454 | -0.000180807 | 179.916 | -0.0093038249043661606,-1.2649414856969455e-10,-0.0079374999998863167 | 0.0093038860381763379,10.78863101178829,0.030490664468159168
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.977Z | Extended Element | 5333587.1361447703,2184678.1832643165,360.93635605774415 | -89.1454 | -0.000191086 | 179.998 | -0.0093038397219187031,5.1315042315522269e-10,-0.0079375000000000001 | 0.0093039654495396598,10.119109573850357,0.030194916442055384
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.988Z | Extended Element | 5333577.3236960014,2184678.0368969515,360.93148920424261 | -89.1454 | -0.0000920785 | -179.924 | -0.0093051848770835735,7.7296140694281435e-11,-0.0079375000011482674 | 0.0093051113007040619,10.922208745011417,0.030662644528338726
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:09.999Z | Extended Element | 5333567.5112635102,2184677.8905298291,360.9130070962342 | -89.1454 | 0.000102272 | -179.85 | -0.0093039011328196058,-8.8164318025243272e-11,-0.0079374999997726299 | 0.009303809896599638,10.304139677741166,0.03113696472348643
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.010Z | Extended Element | 5333546.7781615416,2184677.5812645685,360.83366029761549 | -89.1454 | 180 | -0.2521 | -0.0079375025345061259,-4.0292035543567264e-10,-0.0079375000047075504 | 0.0079374998511475524,10.922023893469289,0.0085657530830481332
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.063Z | Extended Element | 5333598.100214133,2184678.0545710609,360.90408273401579 | 90.8546 | 0.000578073 | 0.0839427 | -0.0093042258370783382,-8.5597779567873093,-0.0093042251901418443 | 0.0093042259795337433,1.2680160113103449,0.025205147338327741
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.078Z | Extended Element | 5333596.846605869,2184678.0358714587,360.92182051166105 | -89.1454 | -0.0000455612 | 179.916 | -0.0093039673834918873,-2.5016902616719285e-11,-0.0079375000011165792 | 0.0093038434526641397,10.682275993275272,0.030642994586029964
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.089Z | Extended Element | 5333587.0341596818,2184677.8895041314,360.93055174856181 | -89.1454 | 0.000340596 | 179.998 | -0.0093039511327925387,-4.9409586494854199e-10,-0.0079374999999431584 | 0.0093038286974683748,10.012754441693863,0.030340269672620258
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.102Z | Extended Element | 5333577.2217108961,2184677.7431367668,360.9255395415347 | -89.1454 | -0.0000815813 | -179.924 | -0.0093038123898612317,3.4684993417326577e-10,-0.0079375000008708434 | 0.0093039326968128722,10.867255562088875,0.030288289789700187
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.114Z | Extended Element | 5333567.4092779448,2184677.596769636,360.90714690630847 | -89.1454 | -0.0000569356 | -179.837 | -0.0093039056025693602,2.7592031966397989e-10,-0.0079375000005067892 | 0.0093038798607562694,10.197783887986169,0.029442583139171676
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.126Z | Extended Element | 5333546.6761771459,2184677.287504395,360.82738454053759 | -89.1454 | -180 | -0.251527 | -0.007937500053506347,6.5807061560712941e-10,-0.0079375000033099722 | 0.0079375001898453808,10.922023827635604,0.0084282332314875568
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.179Z | Extended Element | 5333595.5103068464,2184677.3634022009,360.89477634843348 | -89.1454 | -0.000105109 | -0.0839427 | -0.0093042265447929959,4.4882225533056394e-10,-0.0093042252374004909 | 0.0093042255521190182,10.922230443356623,0.025205147309631304
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.193Z | Extended Element | 5333596.6188852275,2184677.3799382765,360.90905295255328 | -89.1454 | 0.0000353599 | 179.916 | -0.0093038296230733668,6.82617745074361e-11,-0.0079375000023076681 | 0.0093054143658480009,10.909126937884851,0.030849519539805019
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.206Z | Extended Element | 5333586.8064385336,2184677.2335709408,360.91756199529948 | -89.1454 | 0.000202904 | -179.996 | -0.0093038975278149152,-5.2038154997846476e-10,-0.0079375000009362703 | 0.0093039836463490889,9.7752751879024835,0.029741992214114388
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.216Z | Extended Element | 5333576.9939897116,2184677.0872035758,360.91210728906452 | -89.1454 | -0.000092294 | -179.924 | -0.0093038294953810847,3.6534672842150504e-10,-0.0079375000004780344 | 0.0093039734809034491,10.629655309995643,0.030718362033226178
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.225Z | Extended Element | 5333567.1815572586,2184676.9408364529,360.89335674301202 | -89.1454 | -0.0000301964 | -179.837 | -0.0093039135430030874,4.8030149682185619e-11,-0.0079375000018321023 | 0.0093038788176048656,9.9603044327641861,0.029749361901126488
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.234Z | Extended Element | 5333546.4484575484,2184676.6315712286,360.81322415631536 | -89.1454 | -180 | -0.251542 | -0.0079375000420268682,6.3480940041881327e-11,-0.0079374999986129551 | 0.0079375001968008396,10.92202383479847,0.0083675903822708689
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.292Z | Extended Element | 5333595.4305215981,2184677.1335861599,360.89032623965932 | -89.1454 | 0.000023659 | -0.0839427 | -0.0093042252967339041,-3.8604563762887193e-10,-0.0093042251880922754 | 0.0093042255600104921,10.922230538846058,0.0252051469959012
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.302Z | Extended Element | 5333596.5390998935,2184677.1501222705,360.90460284391361 | -89.1454 | 8.79308e-07 | 179.916 | -0.0093038075206694805,-8.2860777512180029e-12,-0.0079375000037556886 | 0.0093039204291273363,10.825922717991833,0.030977644069258167
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.311Z | Extended Element | 5333586.7266530218,2184677.0037549343,360.91298375799437 | -89.1454 | 0.0000670852 | -179.996 | -0.0093053529008910348,-8.3161559932130804e-10,-0.0079375000000000036 | 0.0093050764579477672,10.922209415534937,0.030059149877185391
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.322Z | Extended Element | 5333576.9142041849,2184676.8573875674,360.90742429515655 | -89.1454 | -0.00013738 | -179.924 | -0.0093038070205540297,-2.3350782422576048e-10,-0.0079374999998863133 | 0.0093039075848363306,10.546571962989111,0.030771600647746492
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.334Z | Extended Element | 5333567.101771906,2184676.7110204478,360.88854834968549 | -89.1454 | -0.0000879646 | -179.837 | -0.0093038842411501,-1.2552286805721779e-10,-0.0079375000034971749 | 0.0093038818420392612,9.8770999505120525,0.029856846923261529
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.344Z | Extended Element | 5333546.3686725795,2184676.4017552272,360.80828605055279 | -89.1454 | -180 | -0.251547 | -0.0079374998331002387,1.7987566986333958e-10,-0.0079375000009095052 | 0.0079375004053183484,10.922023838464336,0.0083463095393486349
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.397Z | Extended Element | 5333595.4217028618,2184676.9302314911,360.89011991192393 | -89.1454 | 0.000411633 | -0.0839427 | -0.0093042260486743012,-4.3143583304459359e-11,-0.0093042252659758292 | 0.0093042258523216691,10.922230553492076,0.025205147265811911
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.410Z | Extended Element | 5333596.527625815,2184676.9467281052,360.90440040689344 | -89.1454 | -0.000196129 | 179.916 | -0.0093038682299116555,4.4560149113711569e-10,-0.0079375000037365667 | 0.0093038215551069642,10.81137607328125,0.031004134268979407
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.421Z | Extended Element | 5333586.7125235852,2184676.8003211585,360.91275878333778 | -89.1454 | 0.000214767 | -179.996 | -0.0093053036600803871,-4.587367775376334e-11,-0.0079375000009209717 | 0.00930507222312775,10.922209402015516,0.030080808038889489
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.434Z | Extended Element | 5333576.8974194201,2184676.6539141843,360.90717417071016 | -89.1454 | -0.000108844 | -179.924 | -0.009303811309277453,4.9304653680841063e-10,-0.0079375000015392272 | 0.009303844633827673,10.526714037348345,0.030805530966327564
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.444Z | Extended Element | 5333567.0823318688,2184676.5075074579,360.88826081289 | -89.1454 | -0.000108568 | -179.837 | -0.009303942077957459,-3.0454353943794113e-10,-0.007937500000960605 | 0.0093038854686937379,9.8545863824085238,0.02988936043998688
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.454Z | Extended Element | 5333546.3465773491,2184676.19820263,360.80795179413673 | -89.1454 | -180 | -0.251549 | -0.0079375001253522513,2.3232662132526817e-12,-0.0079375000023054025 | 0.0079375001171965408,10.922023837539221,0.00833986881312717
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.500Z | Extended Element | 5333595.4239758896,2184676.7778481352,360.89011991325759 | -89.1454 | 0.000423605 | -0.0839427 | -0.0093042260486743012,-4.3143583304459359e-11,-0.0093042252659758292 | 0.0093042258523216691,10.922230553492076,0.025205147265811911
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.510Z | Extended Element | 5333596.52989884,2184676.7943447512,360.90440040822568 | -89.1454 | -0.0000875186 | 179.916 | -0.0093038682299116555,4.4560149113711569e-10,-0.0079375000037365667 | 0.0093038215551069642,10.81137607328125,0.031004134268979407
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.519Z | Extended Element | 5333586.714796612,2184676.6479378049,360.91275878467167 | -89.1454 | 0.000219113 | -179.996 | -0.0093053036600803871,-4.587367775376334e-11,-0.0079375000009209717 | 0.00930507222312775,10.922209402015516,0.030080808038889489
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.529Z | Extended Element | 5333576.8996924488,2184676.5015308312,360.90717417204564 | -89.1454 | -0.000192647 | -179.924 | -0.009303811309277453,4.9304653680841063e-10,-0.0079375000015392272 | 0.009303844633827673,10.526714037348345,0.030805530966327564
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.540Z | Extended Element | 5333567.0846048966,2184676.3551241048,360.888260814224 | -89.1454 | -0.000102697 | -179.837 | -0.009303942077957459,-3.0454353943794113e-10,-0.007937500000960605 | 0.0093038854686937379,9.8545863824085238,0.02988936043998688
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:10.550Z | Extended Element | 5333546.348850376,2184676.0458192774,360.80795179546408 | -89.1454 | -180 | -0.251549 | -0.0079375001253522513,2.3232662132526817e-12,-0.0079375000023054025 | 0.0079375001171965408,10.922023837539221,0.00833986881312717
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.243Z | Line | 5333563.4653302664,2184684.5367497541,360.87245354683222 | 0 | 0 | 0 | 0,0,0 | 0.20317780505865812,0.0030307010747492313,0.0010588402801090524
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.254Z | Line | 5333564.319915927,2184686.9983344651,360.82624643442796 | 0 | 0 | 0 | 0,0,0 | 0.20317780133336782,0.0030307015404105186,0.0010272999744529443
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.265Z | Line | 5333565.1745015848,2184689.4599192226,360.7799259659152 | 0 | 0 | 0 | 0,0,0 | 0.20317780412733555,0.0030306568369269371,0.00099690815522990306
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.275Z | Line | 5333562.7123335069,2184682.0766803911,360.87014931522214 | 0 | 0 | 0 | 0,0,0 | 0.85458566248416901,2.4615847137756646,0.0028336517501656999
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.284Z | Line | 5333563.5669191694,2184684.5382651049,360.8729829669723 | 0 | 0 | 0 | 0,0,-0.046222882557117373 | 0.85458565875887871,2.4615847114473581,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.292Z | Line | 5333564.4215048281,2184686.9998498163,360.82676008441518 | 0 | 0 | 0 | 0,0,-0.046335664422372247 | 0.85458565875887871,2.4615847347304225,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.303Z | Line | 5333591.9877772918,2184677.6156928958,360.80681122632302 | 0 | 0 | 0 | 0,0,-0.00059145692034690001 | 0.20317780412733555,0.0030307010747492313,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.312Z | Line | 5333592.0893661939,2184677.6172082466,360.80651549786285 | 0 | 0 | 0 | 0,0,0 | 0.85458565969020128,2.4615847133100033,0.04808392074846779
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.320Z | Line | 5333592.8423629515,2184680.0772776087,360.85490793909077 | 0 | 0 | 0 | 0,0,-0.00061704095890036115 | 0.2031778022646904,0.0030307024717330933,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.328Z | Line | 5333593.6969486093,2184682.5388623201,360.90289244418892 | 0 | 0 | 0 | 0,0,-0.00064262477565080189 | 0.20317780505865812,0.0030307029373943806,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.339Z | Line | 5333594.5515342681,2184685.0004470316,360.90182098149739 | 0 | 0 | 0 | 0,0,-0.00066821083316881413 | 0.20317780505865812,0.0030307015404105186,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.348Z | Line | 5333595.4061199287,2184687.4620317444,360.85169355104694 | 0 | 0 | 0 | 0,0,-0.00069504571109746394 | 0.20317780505865812,0.0030307010747492313,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.357Z | Line | 5333596.2607055893,2184689.9236164554,360.80145391297589 | 0 | 0 | 0 | 0,0,-0.0007193989673055512 | 0.20317780412733555,0.0030307015404105186,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.365Z | Line | 5333592.9439518536,2184680.0787929599,360.85459941861131 | 0 | 0 | 0 | 0,0,0 | 0.85458565782755613,2.4615847114473581,0.04797171318978144
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.375Z | Line | 5333593.7985375114,2184682.5403776714,360.9025711318011 | 0 | 0 | 0 | 0,0,-0.0010842557202863645 | 0.85458565969020128,2.4615847105160356,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.384Z | Line | 5333594.6531231711,2184685.0019623819,360.90148687608081 | 0 | 0 | 0 | 0,0,-0.05014084788939499 | 0.85458565969020128,2.4615847133100033,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.394Z | Line | 5333595.5077088308,2184687.4635470952,360.85134602819141 | 0 | 0 | 0 | 0,0,-0.050251814699208808 | 0.85458566062152386,2.4615847109816968,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.402Z | Line | 5333564.7951191356,2184689.3152286708,360.54125440271798 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709705535
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.413Z | Line | 5333565.6622887347,2184689.3339946144,360.53586317640566 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709705535
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.423Z | Line | 5333564.7933142185,2184689.3101104512,360.28730203478642 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709705535
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.433Z | Line | 5333565.6604838176,2184689.3288763943,360.28191080847409 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709705535
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.443Z | Line | 5333562.3255666103,2184682.2016872293,360.62568292179753 | 0 | 0 | 0 | 0,0,0 | 0.76639374438673258,2.207552982494235,0.0025558739126267938
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.452Z | Line | 5333563.1927265134,2184682.220504486,360.626013377454 | 0 | 0 | 0 | 0,0,0 | 0.76639374438673258,2.2075529829598963,0.0025558739126267938
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.463Z | Line | 5333562.3256410062,2184682.2020016448,360.37168258409525 | 0 | 0 | 0 | 0,0,0 | 0.76639374438673258,2.2075529829598963,0.0025558739126267938
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.473Z | Line | 5333563.1928009083,2184682.2208189019,360.37201303975172 | 0 | 0 | 0 | 0,0,0 | 0.76639374531805515,2.2075529829598963,0.0025558739126267938
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.482Z | Line | 5333562.3379291799,2184679.7589603844,360.57382170450217 | 0 | 0 | 0 | 0,0,0 | 0.76624218374490738,2.2071164264343679,0.046541157192507399
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.491Z | Line | 5333561.4710046081,2184679.7401445573,360.57381610247074 | 0 | 0 | 0 | 0,0,0 | 0.7662421828135848,2.2071164269000292,0.046541157192507399
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.501Z | Line | 5333561.470990831,2184679.7402118701,360.31981558947996 | 0 | 0 | 0 | 0,0,0 | 0.7662421828135848,2.2071164269000292,0.046541157192507399
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.511Z | Line | 5333562.3379154038,2184679.7590276971,360.31982119151132 | 0 | 0 | 0 | 0,0,0 | 0.76624218374490738,2.2071164264343679,0.046541157192507399
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.522Z | Line | 5333560.6164222537,2184677.2785598869,360.52178103656547 | 0 | 0 | 0 | 0,0,0 | 0.76624162215739489,2.2071148091927171,0.04662708333108867
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.531Z | Line | 5333561.4853299633,2184677.3030955731,360.5218524257927 | 0 | 0 | 0 | 0,0,0 | 0.76624162122607231,2.2071148091927171,0.046627083331031827
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.542Z | Line | 5333560.6164045259,2184677.2786271418,360.26778052054891 | 0 | 0 | 0 | 0,0,0 | 0.76624162122607231,2.2071148091927171,0.046627083331031827
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.550Z | Line | 5333561.4853122346,2184677.3031628281,360.26785190977603 | 0 | 0 | 0 | 0,0,0 | 0.76624162122607231,2.2071148091927171,0.046627083331031827
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.561Z | Line | 5333563.1801709747,2184684.6633139155,360.62854107898056 | 0 | 0 | 0 | 0,0,-0.041432120075569401 | 0.76627371273934841,2.2072072983719409,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.569Z | Line | 5333564.0470976066,2184684.6821297593,360.62861104415555 | 0 | 0 | 0 | 0,0,-0.041432120075626244 | 0.76627371273934841,2.2072072988376021,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.580Z | Line | 5333563.1801615078,2184684.663381292,360.37454056894023 | 0 | 0 | 0 | 0,0,-0.041432120075626244 | 0.76627371273934841,2.2072072983719409,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.590Z | Line | 5333564.0470881397,2184684.6821971363,360.37461053411522 | 0 | 0 | 0 | 0,0,-0.041432120075626244 | 0.76627371273934841,2.2072072983719409,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.600Z | Line | 5333561.5847437475,2184677.5902462518,359.96312276224609 | 0 | 0 | 0 | 0,0,0 | 0.5580237889662385,1.6073553492315114,0.033956680243250048
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.610Z | Line | 5333560.7185056703,2184677.5727247852,359.96919153600868 | 0 | 0 | 0 | 0,0,0 | 0.5580237889662385,1.6073553492315114,0.033956680198627964
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.620Z | Line | 5333561.5740068387,2184680.0376445865,360.01508901824548 | 0 | 0 | 0 | 0,0,0 | 0.55802419688552618,1.6073565282858908,0.03389410362677836
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.629Z | Line | 5333562.4407447511,2184680.0559214838,360.01509448608795 | 0 | 0 | 0 | 0,0,0 | 0.55802419688552618,1.6073565282858908,0.03389410362677836
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.639Z | Line | 5333563.2953659287,2184682.5162527096,360.06755440913605 | 0 | 0 | 0 | 0,0,0 | 0.55813457444310188,1.6076744562014937,0.0018613429600122799
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.648Z | Line | 5333562.4282049257,2184682.4974322808,360.06722394980784 | 0 | 0 | 0 | 0,0,0 | 0.55813457444310188,1.6076744562014937,0.0018613429600122799
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.660Z | Line | 5333563.2826150861,2184684.958494103,360.06420159459464 | 0 | 0 | 0 | 0,0,-0.030173391797916338 | 0.55804716050624847,1.6074227071367204,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.668Z | Line | 5333564.1495376453,2184684.9772982188,360.06427177994146 | 0 | 0 | 0 | 0,0,-0.030173391797916338 | 0.55804716050624847,1.6074227066710591,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.677Z | Line | 5333565.0042535774,2184687.4393918826,360.01872301980001 | 0 | 0 | 0 | 0,0,-0.030247391574448557 | 0.55804675538092852,1.6074214563705027,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.703Z | Line | 5333564.1370647028,2184687.4205702902,360.02411423225817 | 0 | 0 | 0 | 0,0,-0.030247391574448557 | 0.55804675444960594,1.6074214563705027,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.713Z | Line | 5333561.0088447379,2184676.7725525866,359.96312280310082 | 0 | 0 | 0 | -0.011365129612386227,0,0 | 0,0.76191676454618573,3.2400748750660568e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.723Z | Line | 5333561.8616930908,2184679.9892330044,360.01512576840321 | 0 | 0 | 0 | 0,-0.76191676454618573,-3.2400748750660568e-12 | 0.011365128681063652,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.732Z | Line | 5333561.8730582194,2184679.2273162398,360.01512576839997 | 0 | 0 | 0 | -0.87557861115783453,-1.6928468886762857,-0.052002965295912418 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.743Z | Line | 5333561.8538025701,2184679.2409583558,360.01512576900251 | 0 | 0 | 0 | -0.011365129612386227,0,-5.6843418860808015e-14 | 0,0.76191676408052444,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.751Z | Line | 5333562.7276438791,2184681.6889009508,360.06703286289991 | 0 | 0 | 0 | -0.011365129612386227,0,-5.6843418860808015e-14 | 0,0.76191676454618573,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.761Z | Line | 5333561.8424374405,2184680.0028751199,360.01512576900245 | 0 | 0 | 0 | 0,0,0 | 0.885206438601017,1.6860258309170604,0.05190709389745507
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.770Z | Line | 5333562.7083882289,2184681.7025430668,360.06703286337466 | 0 | 0 | 0 | -0.011365130543708801,0,0 | 0,0.76191676594316959,3.1832314562052488e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.780Z | Line | 5333563.5822295407,2184684.1504856623,360.06988285191255 | 0 | 0 | 0 | -0.011365131475031376,0,0 | 0,0.76191676501184702,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.790Z | Line | 5333562.6970230984,2184682.4644598328,360.06703286337785 | 0 | 0 | 0 | 0,0,0 | 0.8852064423263073,1.6860258295200765,0.0028499885347059717
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.799Z | Line | 5333563.5629738905,2184684.1641277787,360.06988285106127 | 0 | 0 | 0 | -0.011365131475031376,0,0 | 0,0.76191676501184702,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.809Z | Line | 5333564.4368151985,2184686.6120704329,360.02367573864063 | 0 | 0 | 0 | -0.011365130543708801,0,0 | 0,0.76191676454618573,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.818Z | Line | 5333564.4175595483,2184686.6257125498,360.02367573949198 | 0 | 0 | 0 | -0.011365129612386227,0,0 | 0,0.76191676454618573,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.829Z | Line | 5333563.551608759,2184684.9260445437,360.06988285106297 | 0 | 0 | 0 | 0,0,-0.046207112422337104 | 0.88520643953233957,1.6860258891247213,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.837Z | Line | 5333565.2817730345,2184689.0804761453,359.97735527056551 | 0 | 0 | 0 | -0.011365128681063652,0,-1.5916157281026244e-12 | 0,0.76191676501184702,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.849Z | Line | 5333564.4061944187,2184687.3876293143,360.02367573949368 | 0 | 0 | 0 | 0,0,-0.046320468928172431 | 0.8755786158144474,1.6928468309342861,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.858Z | Line | 5333592.0950487368,2184677.2362498641,360.00290046621956 | 0 | 0 | 0 | -0.011365128681063652,0,0 | 0,0.76191676501184702,3.2400748750660568e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.868Z | Line | 5333592.9592622193,2184679.6910135178,360.05490343151871 | 0 | 0 | 0 | -0.87557861115783453,-1.6928468886762857,-0.052002965295912418 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.877Z | Line | 5333592.9478970906,2184680.4529302823,360.05490343152195 | 0 | 0 | 0 | 0,-0.76191676454618573,-3.2400748750660568e-12 | 0.011365128681063652,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.885Z | Line | 5333592.940006569,2184679.7046556338,360.05490343212125 | 0 | 0 | 0 | -0.011365128681063652,0,-5.6843418860808015e-14 | 0,0.76191676408052444,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.896Z | Line | 5333592.9286414403,2184680.4665723979,360.05490343212119 | 0 | 0 | 0 | 0,0,0 | 0.88520643766969442,1.6860258309170604,0.05190709389745507
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.904Z | Line | 5333593.813847878,2184682.1525982288,360.10681052601865 | 0 | 0 | 0 | -0.011365128681063652,0,-5.6843418860808015e-14 | 0,0.76191676408052444,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.915Z | Line | 5333593.7945922278,2184682.1662403448,360.1068105264934 | 0 | 0 | 0 | -0.011365129612386227,0,0 | 0,0.76191676547750831,3.1832314562052488e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.923Z | Line | 5333593.7832270982,2184682.9281571102,360.10681052649659 | 0 | 0 | 0 | 0,0,0 | 0.88520644139498472,1.6860258299857378,0.0028499885347059717
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.931Z | Line | 5333594.6684335396,2184684.6141829402,360.10966051503129 | 0 | 0 | 0 | -0.011365130543708801,0,0 | 0,0.76191676501184702,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.939Z | Line | 5333594.6491778893,2184684.6278250567,360.10966051418001 | 0 | 0 | 0 | -0.011365130543708801,0,0 | 0,0.76191676501184702,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.947Z | Line | 5333594.6378127588,2184685.3897418217,360.10966051418171 | 0 | 0 | 0 | 0,0,-0.046207112422337104 | 0.885206438601017,1.6860258891247213,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.958Z | Line | 5333595.5230191974,2184687.0757677108,360.06345340175938 | 0 | 0 | 0 | -0.011365129612386227,0,0 | 0,0.76191676454618573,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.966Z | Line | 5333595.5037635472,2184687.0894098277,360.06345340261072 | 0 | 0 | 0 | -0.011365129612386227,0,0 | 0,0.76191676454618573,1.7053025658242404e-12
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.976Z | Line | 5333595.4923984176,2184687.8513265923,360.06345340261242 | 0 | 0 | 0 | 0,0,-0.046320468928172431 | 0.8755786158144474,1.6928468309342861,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.984Z | Line | 5333596.3679770334,2184689.5441734232,360.01713293368425 | 0 | 0 | 0 | -0.011365127749741077,0,-1.5916157281026244e-12 | 0,0.76191676501184702,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:11.994Z | Line | 5333591.7025801456,2184677.7422567331,360.5615586834341 | 0 | 0 | 0 | 0,0,0 | 0.76624162122607231,2.2071148091927171,0.04662708333108867
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.003Z | Line | 5333591.7026078198,2184677.7423246643,360.30755818366583 | 0 | 0 | 0 | 0,0,0 | 0.76624162122607231,2.2071148091927171,0.046627083331031827
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.014Z | Line | 5333591.8047089651,2184678.0364223076,360.00896919912554 | 0 | 0 | 0 | 0,0,0 | 0.5580237889662385,1.6073553492315114,0.033956680198684808
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.023Z | Line | 5333592.5714885602,2184677.7667921744,360.56163007266281 | 0 | 0 | 0 | 0,0,0 | 0.76624162122607231,2.2071148087270558,0.046627083331031827
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.033Z | Line | 5333592.5715162354,2184677.7668601056,360.30762957289443 | 0 | 0 | 0 | 0,0,0 | 0.76624162122607231,2.2071148091927171,0.046627083331031827
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.043Z | Line | 5333592.6709477482,2184678.0539435293,360.00290042536449 | 0 | 0 | 0 | 0,0,0 | 0.5580237889662385,1.6073553492315114,0.033956680243250048
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.052Z | Line | 5333592.5571624795,2184680.2038414027,360.61359375287469 | 0 | 0 | 0 | 0,0,0 | 0.76624218374490738,2.2071164269000292,0.046541157192564242
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.062Z | Line | 5333592.5571941249,2184680.2039093925,360.35959325259688 | 0 | 0 | 0 | 0,0,0 | 0.76624218374490738,2.2071164269000292,0.046541157192507399
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.073Z | Line | 5333592.6602101326,2184680.5013421089,360.0548666813624 | 0 | 0 | 0 | 0,0,0 | 0.55802419688552618,1.6073565282858908,0.03389410362677836
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.082Z | Line | 5333593.4240877582,2184680.2226569843,360.61359935490759 | 0 | 0 | 0 | 0,0,0 | 0.7662421828135848,2.2071164269000292,0.046541157192507399
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.092Z | Line | 5333593.4241194045,2184680.2227249742,360.35959885462967 | 0 | 0 | 0 | 0,0,0 | 0.7662421828135848,2.2071164269000292,0.046541157192564242
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.102Z | Line | 5333593.526948751,2184680.5196187608,360.05487214920635 | 0 | 0 | 0 | 0,0,0 | 0.55802419781684875,1.6073565287515521,0.03389410362677836
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.113Z | Line | 5333593.4117217939,2184682.6653840332,360.66546057460795 | 0 | 0 | 0 | 0,0,0 | 0.76639374438673258,2.207552982494235,0.0025558739126267938
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.124Z | Line | 5333593.4118443001,2184682.6656991676,360.41146024721212 | 0 | 0 | 0 | 0,0,0 | 0.76639374438673258,2.207552982494235,0.0025558739126836372
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.133Z | Line | 5333593.5144082196,2184682.9611298032,360.10700161292476 | 0 | 0 | 0 | 0,0,0 | 0.55813457537442446,1.6076744562014937,0.0018613429600122799
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.145Z | Line | 5333594.2788824029,2184682.684201045,360.66579103026589 | 0 | 0 | 0 | 0,0,0 | 0.76639374438673258,2.207552982494235,0.0025558739126267938
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.154Z | Line | 5333594.2790049091,2184682.6845161794,360.41179070287012 | 0 | 0 | 0 | 0,0,0 | 0.76639374438673258,2.207552982494235,0.0025558739126267938
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.164Z | Line | 5333594.3815699285,2184682.979949987,360.10733207225445 | 0 | 0 | 0 | 0,0,0 | 0.55813457537442446,1.6076744562014937,0.0018613429600122799
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.175Z | Line | 5333594.2663231576,2184685.1270106747,360.66831873499137 | 0 | 0 | 0 | 0,0,-0.041432120075626244 | 0.76627371273934841,2.2072072983719409,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.185Z | Line | 5333594.2663648017,2184685.1270788144,360.41431823205716 | 0 | 0 | 0 | 0,0,-0.041432120075626244 | 0.76627371273934841,2.2072072983719409,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.198Z | Line | 5333594.3688183799,2184685.4221916259,360.10397925771156 | 0 | 0 | 0 | 0,0,-0.030173391797916338 | 0.55804716050624847,1.6074227066710591,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.209Z | Line | 5333595.1332504954,2184685.1458262736,360.66838870016784 | 0 | 0 | 0 | 0,0,-0.041432120075626244 | 0.76627371273934841,2.2072072983719409,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.220Z | Line | 5333595.1332921395,2184685.1458944138,360.41438819723356 | 0 | 0 | 0 | 0,0,-0.041432120075569401 | 0.76627371273934841,2.2072072983719409,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.231Z | Line | 5333595.235741646,2184685.4409954962,360.10404944305986 | 0 | 0 | 0 | 0,0,-0.030173391797916338 | 0.55804716050624847,1.6074227066710591,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.242Z | Line | 5333595.8812968973,2184689.7789258137,360.58103206454371 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709705535
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.251Z | Line | 5333595.8795175124,2184689.7738079736,360.32707969790329 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709762378
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.263Z | Line | 5333595.2232679967,2184687.8842678126,360.06389189537509 | 0 | 0 | 0 | 0,0,-0.030247391574448557 | 0.55804675538092852,1.6074214563705027,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.273Z | Line | 5333596.7484672023,2184689.7976915124,360.57564083823286 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709705535
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.285Z | Line | 5333596.7466878183,2184689.7925736718,360.32168847159244 | 0 | 0 | 0 | -0.76627315580844879,-2.2072055819444358,0 | 0,0,0.041533731709762378
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.296Z | Line | 5333596.0904575782,2184687.9030891596,360.05850068291841 | 0 | 0 | 0 | 0,0,-0.030247391574448557 | 0.55804675444960594,1.607421456836164,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.307Z | Line | 5333551.053644212,2184689.2492854483,360.74834987914477 | 0 | 0 | 0 | 0,0,-0.9143998723498612 | 0.0018913401290774345,2.8212089091539383e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.318Z | Line | 5333550.1990585523,2184686.7877007355,360.79337151680807 | 0 | 0 | 0 | 0,0,-0.91439969452250125 | 0.0019754283130168915,2.9466580599546432e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.331Z | Line | 5333549.3444728944,2184684.3261160231,360.83839427210364 | 0 | 0 | 0 | 0,0,-0.91439952562546978 | 0.0020521003752946854,3.0610710382461548e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.341Z | Line | 5333548.4898872338,2184681.8645313131,360.83447287755615 | 0 | 0 | 0 | 0,0,-0.914399367294493 | 0.0021214643493294716,3.1644944101572037e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.353Z | Line | 5333547.6353015741,2184679.4029466016,360.78160784307966 | 0 | 0 | 0 | 0,0,-0.91439922127312911 | 0.0021834820508956909,3.2569281756877899e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.363Z | Line | 5333546.7807159154,2184676.9413618864,360.72874277558174 | 0 | 0 | 0 | 0,0,-0.91439908903612377 | 0.0022381618618965149,3.3385585993528366e-05,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.374Z | Complex Chain | 5333596.1426822254,2184690.4370580381,360.11217294062067 | 0 | 0 | 0 | 0,0,-0.15711012494357973 | 0.54302040416460795,0.0080999713265681381,0.00071938003429750097
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.383Z | Complex Chain | 5333596.2857634025,2184690.4558629394,360.95532330901102 | 0 | 0 | 0 | -0.14440275564310878,-0.0021539745847963931,-1.0002649848894107 | 0.39969061895726077,0.0059619998554968452,0.00047540309351327276
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.394Z | Line | 5333545.8881042097,2184676.3437810913,360.63226232901371 | 0 | 0 | 0 | 0,0,-1.7490719983470626e-10 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.402Z | Line | 5333546.9838937176,2184676.9443925866,360.97414635224737 | 0 | 0 | 0 | 0,0,-1.0921989118996862 | 0.0026733623817563057,3.9876904338598251e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.413Z | Line | 5333546.1920551695,2184677.2192943054,360.64967997914766 | 0 | 0 | 0 | 0,0,-0.38100076200151989 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.421Z | Line | 5333546.5519817816,2184677.0943389782,360.64707378456757 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,-0.83820167640334375 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.434Z | Line | 5333546.1920551695,2184677.2192943054,360.59094236167243 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.443Z | Line | 5333547.8384793792,2184679.4059773036,361.02311765014139 | 0 | 0 | 0 | 0,0,-1.092199069861465 | 0.0026080440729856491,3.8902275264263153e-05,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.451Z | Line | 5333547.046640832,2184679.680879022,360.69865127565777 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,-0.38100076200151989 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.461Z | Line | 5333547.4065674441,2184679.5559236957,360.69604508270527 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,-0.83820167640334375 | 9.3132257461547852e-10,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.470Z | Line | 5333547.046640832,2184679.680879022,360.63991365818248 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.480Z | Line | 5333547.9012264898,2184682.1424637306,360.74762257398515 | 0 | 0 | 0 | 0,0,-0.38100076200157673 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.491Z | Line | 5333548.2611531029,2184682.0175084039,360.74501638070598 | 0 | 0 | 0 | 0,0,-0.8382016764034006 | 0,4.6566128730773926e-10,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.500Z | Line | 5333548.693065038,2184681.8675620132,361.07208894856649 | 0 | 0 | 0 | 0,0,-1.0922021844044139 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.511Z | Line | 5333547.9012264898,2184682.1424637311,360.68888495650987 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061932791776599 | 0.359926613047719,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.519Z | Line | 5333548.7558121523,2184684.604048443,360.73993273172999 | 0 | 0 | 0 | -9.3132257461547852e-10,-9.3132257461547852e-10,-0.38100076200151989 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.530Z | Line | 5333549.1157385986,2184684.4790926441,360.74221315907073 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,-0.83820167640334375 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.541Z | Line | 5333548.7558121523,2184684.604048443,360.68119511425476 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644634097815,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.550Z | Line | 5333549.5476506976,2184684.3291467251,361.07514965503418 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,-1.092202184404357 | 9.3132257461547852e-10,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.562Z | Line | 5333549.6103978101,2184687.0656331554,360.69708284617491 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,-0.38100076200151989 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.570Z | Line | 5333549.9703240143,2184686.9406779688,360.69936343114261 | 0 | 0 | 0 | 0,0,-0.8382016764034006 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.578Z | Line | 5333550.4022363583,2184686.7907314366,361.0322997683042 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,-1.092202184404357 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.586Z | Line | 5333549.6103978101,2184687.0656331554,360.63834522869962 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.596Z | Line | 5333550.4649834698,2184689.5272178669,360.65423296137391 | 0 | 0 | 0 | 0,0,-0.38100076200163357 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.605Z | Line | 5333550.8249100819,2184689.4022625396,360.65651337946974 | 0 | 0 | 0 | 0,0,-0.8382016764034006 | 9.3132257461547852e-10,4.6566128730773926e-10,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.616Z | Line | 5333551.256822017,2184689.2523161485,360.98944988283182 | 0 | 0 | 0 | 0,0,-1.092202184404357 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.626Z | Line | 5333550.4649834698,2184689.5272178669,360.59549534389862 | 0 | 0 | 0 | 0,-0.12495532725006342,0 | 0.35992661211639643,0,0.0022804180958928555
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.637Z | Line | 5333548.2284632772,2184683.085050426,360.70763697976298 | 0 | 0 | 0 | 0,0,-0.11734823469646471 | 2.3403590684756637,6.7412693346850574,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.652Z | Line | 5333545.8881042097,2184676.3437810908,360.57352471153843 | 0 | 0 | 0 | 0,0,0 | 2.3403590675443411,6.7412693351507187,0.13411226822455546
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.663Z | Line | 5333546.2003855407,2184677.2432894609,360.5914197252439 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.672Z | Line | 5333546.2061126726,2184677.2597861299,360.59174791363012 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.683Z | Line | 5333546.3253411194,2184677.603216792,360.59858019702756 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661118507385,0,0
