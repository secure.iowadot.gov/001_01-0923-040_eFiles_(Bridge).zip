Properties of the parts of a building model (IFC4X3_ADD2), part 12 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.169Z | Extended Element | 5333581.1323271599,2184678.5460912962,361.01535509325902 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.180Z | Extended Element | 5333581.4116965747,2184678.5502585089,361.01554731174292 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.198Z | Extended Element | 5333581.6910660015,2184678.5544257211,361.01571624452367 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.209Z | Extended Element | 5333581.9704354517,2184678.5585929356,361.01584830685016 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.218Z | Extended Element | 5333582.2498049,2184678.5627601491,361.01598036916846 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.229Z | Extended Element | 5333582.5291743483,2184678.5669273622,361.01611243144924 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.238Z | Extended Element | 5333582.8085437985,2184678.5710945763,361.01624449377169 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.250Z | Extended Element | 5333583.0879132487,2184678.5752617903,361.0163765560855 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.267Z | Extended Element | 5333583.3672827166,2184678.5794290039,361.0164525202398 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.277Z | Extended Element | 5333583.64665219,2184678.5835962179,361.01652442631985 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.287Z | Extended Element | 5333583.9260216607,2184678.5877634315,361.01659633242821 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.297Z | Extended Element | 5333584.2053911313,2184678.5919306455,361.0166682385094 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.306Z | Extended Element | 5333584.484760602,2184678.5960978596,361.01674014462719 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.323Z | Extended Element | 5333584.7641300764,2184678.6002650731,361.01678767669074 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.333Z | Extended Element | 5333585.0434995554,2184678.6044322881,361.01680859068199 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.344Z | Extended Element | 5333585.3228690363,2184678.6085995021,361.01682950468637 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.353Z | Extended Element | 5333585.6022385163,2184678.6127667162,361.01685041867188 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.370Z | Extended Element | 5333585.8816079972,2184678.6169339302,361.01685071930666 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.387Z | Extended Element | 5333586.1609774772,2184678.6211011442,361.01684063494605 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.398Z | Extended Element | 5333586.4403469535,2184678.6252683587,361.01679222860139 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.410Z | Extended Element | 5333586.7197164288,2184678.6294355728,361.01674382224655 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.419Z | Extended Element | 5333586.9990859041,2184678.6336027863,361.01669541589126 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.429Z | Extended Element | 5333587.2784553822,2184678.6377699999,361.01664700953614 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.441Z | Extended Element | 5333587.5578248575,2184678.6419372144,361.01659860318102 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.458Z | Extended Element | 5333587.8371943245,2184678.6461044289,361.01651597366339 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.467Z | Extended Element | 5333588.116563783,2184678.6502716416,361.01640741110407 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.479Z | Extended Element | 5333588.3959332425,2184678.6544388556,361.016298848514 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.487Z | Extended Element | 5333588.6753027029,2184678.6586060696,361.01619028594348 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.499Z | Extended Element | 5333588.9546721615,2184678.6627732841,361.01608172338541 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.517Z | Extended Element | 5333589.2340416173,2184678.6669404972,361.01596628139902 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.527Z | Extended Element | 5333589.5134110469,2184678.6711077103,361.01579756262799 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.537Z | Extended Element | 5333589.7927804748,2184678.6752749244,361.01562884385214 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.548Z | Extended Element | 5333590.0721499035,2184678.679442137,361.01546012507293 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.559Z | Extended Element | 5333590.351519336,2184678.6836093501,361.01529140629924 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.569Z | Extended Element | 5333590.6308887647,2184678.6877765637,361.01512268751623 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.587Z | Extended Element | 5333590.9102581646,2184678.6919437768,361.01491427695191 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.598Z | Extended Element | 5333591.1896275552,2184678.6961109899,361.01468540199937 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.609Z | Extended Element | 5333591.4689969392,2184678.7002782021,361.01445652702625 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.618Z | Extended Element | 5333591.748366327,2184678.7044454142,361.01422765207673 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.626Z | Extended Element | 5333592.027735712,2184678.7086126269,361.01399877712197 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.642Z | Extended Element | 5333592.3071050867,2184678.71277984,361.0137575542056 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.651Z | Extended Element | 5333592.5864744186,2184678.7169470517,361.01346852309734 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.663Z | Extended Element | 5333592.8658437505,2184678.7211142643,361.01317949199688 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.674Z | Extended Element | 5333593.1452130796,2184678.7252814756,361.01289046088948 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.683Z | Extended Element | 5333593.4245824125,2184678.7294486878,361.01260142978737 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.696Z | Extended Element | 5333593.7039517434,2184678.7336158995,361.01231239868179 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.713Z | Extended Element | 5333593.9833210222,2184678.7377831107,361.01197820737212 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.724Z | Extended Element | 5333594.2626902843,2184678.741950321,361.01162902016245 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.735Z | Extended Element | 5333594.5420595445,2184678.7461175327,361.01127983296857 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.747Z | Extended Element | 5333594.8214288084,2184678.7502847435,361.01093064574059 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.758Z | Extended Element | 5333595.1007980695,2184678.7544519547,361.01058145852937 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.777Z | Extended Element | 5333595.3801673073,2184678.7586191646,361.01021445507143 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.786Z | Extended Element | 5333595.6595364884,2184678.7627863744,361.00980511179728 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.798Z | Extended Element | 5333595.9389056703,2184678.7669535843,361.00939576851886 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.809Z | Extended Element | 5333596.2182748513,2184678.7711207937,361.00898642524862 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.819Z | Extended Element | 5333596.4976440296,2184678.775288003,361.00857708198851 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.831Z | Extended Element | 5333596.7770132106,2184678.7794552129,361.00816773871401 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.849Z | Extended Element | 5333597.0563823124,2184678.7836224209,361.00770776719378 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.860Z | Extended Element | 5333597.3357513994,2184678.7877896298,361.00723826791449 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.871Z | Extended Element | 5333597.6151204845,2184678.7919568378,361.00676876864725 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.883Z | Extended Element | 5333597.8944895715,2184678.7961240462,361.00629926937484 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.892Z | Extended Element | 5333598.1738586575,2184678.8002912547,361.00582977009111 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.907Z | Extended Element | 5333598.4532277007,2184678.8044584622,361.00533698669875 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.916Z | Extended Element | 5333598.7325966805,2184678.8086256683,361.00480733149061 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.927Z | Extended Element | 5333599.0119656576,2184678.8127928753,361.00427767628179 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.937Z | Extended Element | 5333599.2913346356,2184678.816960081,361.00374802107751 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.949Z | Extended Element | 5333599.5707036145,2184678.821127288,361.00321836585357 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.960Z | Extended Element | 5333599.8500725944,2184678.8252944942,361.0026887106564 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.976Z | Extended Element | 5333600.1294414587,2184678.8294617003,361.00210295966167 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.987Z | Extended Element | 5333600.4088103157,2184678.8336289041,361.00151314857379 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:33.999Z | Extended Element | 5333600.6881791744,2184678.8377961097,361.00092333749967 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.010Z | Extended Element | 5333600.9675480332,2184678.841963314,361.00033352643328 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.020Z | Extended Element | 5333601.2469168911,2184678.8461305187,360.99974371535137 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.038Z | Extended Element | 5333601.5262856865,2184678.850297723,360.9991251528362 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.049Z | Extended Element | 5333601.8056544093,2184678.8544649254,360.99847518598585 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.059Z | Extended Element | 5333602.0850231331,2184678.8586321273,360.99782521912641 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.070Z | Extended Element | 5333602.3643918596,2184678.8627993315,360.99717525225816 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.082Z | Extended Element | 5333602.6437605834,2184678.8669665339,360.99652528541367 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.101Z | Extended Element | 5333602.9231293043,2184678.8711337359,360.99587391153966 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.112Z | Extended Element | 5333603.2024978818,2184678.8753009373,360.99516378899528 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.122Z | Extended Element | 5333603.4818664612,2184678.8794681383,360.99445366643801 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.133Z | Extended Element | 5333603.7612350406,2184678.8836353393,360.99374354389528 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.144Z | Extended Element | 5333604.0406036153,2184678.8878025394,360.99303342133487 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.154Z | Extended Element | 5333604.3199721938,2184678.8919697399,360.99232329879783 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.172Z | Extended Element | 5333604.599340681,2184678.8961369395,360.99157895816006 | 0.8546 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.184Z | Extended Element | 5333604.8787090993,2184678.9003041377,360.99080868001886 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.196Z | Extended Element | 5333605.1580775194,2184678.9044713359,360.9900384018718 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.205Z | Extended Element | 5333605.4374459367,2184678.9086385341,360.98926812374316 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.216Z | Extended Element | 5333605.7168143578,2184678.9128057323,360.98849784559775 | 0.854601 | 179.999 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.233Z | Extended Element | 5333605.9961827556,2184678.9169729305,360.9877206940788 | 0.854592 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.245Z | Extended Element | 5333606.2755510015,2184678.9211401264,360.98689026044826 | 0.854593 | 180 | -1.14577 | -0.010873055988390629,-1.3083313305589166e-10,-0.010734767333001343 | 0.010872964243614265,10.056789884407031,0.2106455648888769
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.254Z | Complex Chain | 5333550.2601321461,2184687.586262085,360.94126689702347 | 0 | 0 | 0 | 0,-9.4985623355023563,-0.011177322398225442 | 0.14168515894562006,0,0.080644569761432194
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.265Z | Complex Chain | 5333549.9921277827,2184686.8201781032,360.95527746061845 | 0 | 0 | 0 | 0,-8.7366455672308803,-0.026417248583527453 | 0.13032003957778215,0,0.065404643576130184
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.276Z | Complex Chain | 5333549.7245022571,2184686.028696896,360.9697960204827 | 0 | 0 | 0 | 0,-7.9493315741419792,-0.042165170276291519 | 0.11857608426362276,0,0.049656721883366117
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.285Z | Complex Chain | 5333549.4564978946,2184685.2626129147,360.9838065841688 | 0 | 0 | 0 | 0,-7.1874148086644709,-0.05740509646159353 | 0.10721096675843,0,0.034416795698007263
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.296Z | Complex Chain | 5333549.1884935312,2184684.4965289338,360.99781714690022 | 0 | 0 | 0 | 0,-6.4254980408586562,-0.072645022646895541 | 0.095845846459269524,0,0.019176869512762096
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.304Z | Complex Chain | 5333548.9204892153,2184683.7304418576,361.01113433912928 | 0 | 0 | 0 | 0,-5.6635781773366034,-0.08719157703228575 | 0.084480681456625462,0,0.0046303151273718868
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.316Z | Complex Chain | 5333548.6528636469,2184682.9389637471,361.01453525012414 | 0 | 0 | 0 | 0,-4.8762672832235694,-0.091821850638041269 | 0.072736768983304501,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.326Z | Line | 5333548.3848592872,2184682.1728797737,361.00378076500851 | 0 | 0 | 0 | 0,-4.1143505200743675,-0.082296727783955248 | 0.061371647752821445,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.337Z | Line | 5333548.166861454,2184678.0543620428,360.92025467473405 | 0 | 0 | 0 | -0.050006527453660965,0,0 | 0,3.3524337559938431,0.067056593009283461
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.345Z | Line | 5333547.8874919722,2184678.050194832,360.91902531264577 | 0 | 0 | 0 | -0.038641407154500484,0,0 | 0,2.5905169928446412,0.051816458234497986
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.353Z | Line | 5333547.6081224931,2184678.0460276227,360.91779594970126 | 0 | 0 | 0 | -0.027276287786662579,0,0 | 0,1.8286002292297781,0.036576323459655669
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.361Z | Line | 5333547.3287530113,2184678.0418604109,360.91656658787542 | 0 | 0 | 0 | -0.015911168418824673,0,0 | 0,1.0666834670118988,0.021336188684756507
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.370Z | Complex Chain | 5333550.7961408701,2184689.1184300277,360.91324576988274 | 0 | 0 | 0 | 0,-11.022395868785679,0 | 0.16441539954394102,0,0.11112442213197937
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.382Z | Complex Chain | 5333550.5281365085,2184688.3523460645,360.92725633295953 | 0 | 0 | 0 | 0,-10.260479101911187,0 | 0.15305027831345797,0,0.095884495946734205
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.412Z | Extended Element | 5333550.7961408691,2184689.1184300282,360.91324576987444 | 0.854578 | -0.000501551 | 178.854 | -0.010872968736177348,2.1622703572000873e-10,-0.010735101076237619 | 0.010873022627417033,11.02218483585512,0.21064556141233048
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.441Z | Extended Element | 5333550.5281365085,2184688.3523460645,360.92725633296817 | 0.854578 | -0.000490871 | 178.854 | -0.010872828259015527,1.8066786191076133e-10,-0.010735092565822113 | 0.010873191967595617,10.260030926853391,0.21064556117028474
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.467Z | Extended Element | 5333550.4018173059,2184678.0876997504,360.93008957463638 | 0.854593 | 180 | -1.14577 | -0.010873038352428886,-2.1703529552472369e-11,-0.010734767183728358 | 0.010872951073567238,9.4983239697849271,0.18829798827228511
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.494Z | Extended Element | 5333550.1224478213,2184678.0835325359,360.92886021203816 | 0.854593 | 180 | -1.14577 | -0.010873058187497944,-1.7624834992500752e-10,-0.010735210852066652 | 0.010872964071565419,8.7367795381817572,0.15782402148696717
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.522Z | Extended Element | 5333549.8430783423,2184678.0793653214,360.92763085020232 | 0.854592 | 180 | -1.14577 | -0.01087303596427169,3.775957235849291e-11,-0.010734767323177311 | 0.010872953464909426,7.9498502948417489,0.12633425784829072
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.550Z | Extended Element | 5333549.5637088604,2184678.075198106,360.92640148772438 | 0.854593 | 180 | -1.14577 | -0.010873055414109749,-2.0468783298085698e-10,-0.010735210842415521 | 0.010872964817854122,7.1883058655381111,0.09586029110589217
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.580Z | Extended Element | 5333549.2843393786,2184678.0710308929,360.92517212426657 | 0.854592 | 180 | -1.14577 | -0.010873035151299497,-1.1112394166143722e-12,-0.010734767203146433 | 0.010872954276090075,6.4267614354983733,0.065386324292523737
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.609Z | Extended Element | 5333549.0049698986,2184678.0668636812,360.92394276208887 | 0.854592 | 180 | -1.14577 | -0.01087303884965503,1.3488958723640084e-10,-0.010735210918328665 | 0.010872950577470805,5.6651583688410785,0.036054586461760268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.636Z | Extended Element | 5333548.7256004158,2184678.0626964644,360.92271339947712 | 0.854593 | 180 | -1.14577 | -0.010872269097985599,-9.258106440834125e-11,-0.01073521085315363 | 0.010872254065522819,4.877795110106824,0.015238057272733132
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.664Z | Extended Element | 5333548.384859289,2184682.1728797737,361.00378076500334 | 112.107 | -88.7706 | -68.7517 | -0.0095250009566752343,3.7205727672162024e-11,-0.0095249998098501862 | 0.0095250000031975122,4.115631108806868,0.0095250011438529261
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.691Z | Extended Element | 5333548.1668614559,2184678.0543620433,360.9202546747278 | -67.8927 | 88.7706 | 68.7517 | -0.0095250000031661449,2.9959288468135974e-11,-0.0095249998824654333 | 0.0095249999983558729,3.353477199584411,0.0095250001175431667
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.714Z | Extended Element | 5333547.887491974,2184678.050194832,360.91902531264566 | -67.8927 | 88.7706 | 68.7517 | -0.0095250000005175813,1.1657719681726852e-10,-0.0095250001955375918 | 0.0095250000011242331,2.5913232904646413,0.0095249998044744065
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.737Z | Extended Element | 5333547.6081224931,2184678.0460276227,360.91779594971473 | -67.8927 | 88.7706 | 68.7517 | -0.0095250009534048677,2.436577921028166e-11,-0.0095250007718907046 | 0.0095250000027983575,1.8291693802322175,0.0095250001818097691
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.766Z | Extended Element | 5333547.3287530104,2184678.0418604114,360.91656658787053 | -67.8927 | 88.7706 | 68.7517 | -0.0095250000033610359,-3.6725459609003992e-11,-0.0095250004824031786 | 0.0095249999974684266,1.0670154716601425,0.0095249995176113766
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.774Z | Complex Chain | 5333606.404900413,2184688.9826086466,360.98606119860699 | 0 | 0 | 0 | 0,-11.022395862732083,-0.019305545211807384 | 0.16441539581865072,0,0.091820516646691885
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.797Z | Extended Element | 5333606.5693158098,2184677.9602127844,360.9667556534053 | 0.854593 | 180 | -1.14577 | -0.010872968736177348,2.1622703572000873e-10,-0.010735101076237619 | 0.010873022627417033,11.02218483585512,0.21064556141233048
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.805Z | Complex Chain | 5333606.684269893,2184688.9867758583,360.98523076122939 | 0 | 0 | 0 | 0,-10.260479099582881,-0.0040654104369650668 | 0.15305027738213539,0,0.091820516646691885
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.817Z | Complex Chain | 5333606.9636393739,2184688.9909430733,360.98440032433598 | 0 | 0 | 0 | 0,-9.4985623373650014,0 | 0.14168515708297491,0,0.091820516646691885
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.828Z | Complex Chain | 5333607.2430088548,2184688.995110285,360.98356988696474 | 0 | 0 | 0 | 0,-8.7366455746814609,0 | 0.13032003678381443,0,0.091820516646691885
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.837Z | Complex Chain | 5333607.5223783338,2184688.9992775014,360.98269976447045 | 0 | 0 | 0 | 0,-7.9493315857835114,0 | 0.11857608053833246,0,0.091820516646691885
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.848Z | Complex Chain | 5333607.8017478138,2184689.0034447149,360.98180917041014 | 0 | 0 | 0 | 0,-7.1874148230999708,0 | 0.10721095930784941,0,0.091820516646691885
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.859Z | Complex Chain | 5333608.0811172938,2184689.0076119266,360.98091857643789 | 0 | 0 | 0 | 0,-6.4254980613477528,0 | 0.095845839940011501,0,0.091820516646691885
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.870Z | Complex Chain | 5333608.3604867728,2184689.0117791439,360.9800279833392 | 0 | 0 | 0 | 0,-5.6635774727910757,0 | 0.084480664692819118,0,0.091820516646691885
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.880Z | Complex Chain | 5333608.6398562556,2184689.0159463543,360.97913738988882 | 0 | 0 | 0 | 0,-4.8762673079036176,0 | 0.072736761532723904,0,0.091820516646691885
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.889Z | Line | 5333608.9192257365,2184689.0201135646,360.97823445445181 | 0 | 0 | 0 | 0,-4.1143505414947867,0 | 0.061371643096208572,0,0.082295601400574014
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.900Z | Line | 5333609.1985952174,2184689.0242807744,360.97728370461408 | 0 | 0 | 0 | 0,-3.3524337760172784,0 | 0.050006525591015816,0,0.067055675215328847
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.911Z | Line | 5333609.4779646974,2184689.0284479838,360.97633295507865 | 0 | 0 | 0 | 0,-2.590517008677125,0 | 0.038641407154500484,0,0.051815749029969993
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.921Z | Line | 5333609.7573341765,2184689.0326151946,360.97538220508943 | 0 | 0 | 0 | 0,-1.8286002422682941,0 | 0.027276287786662579,0,0.036575822844667982
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.931Z | Line | 5333610.0367036555,2184689.0367824044,360.97443145545145 | 0 | 0 | 0 | 0,-1.0666834744624794,0 | 0.015911167487502098,0,0.021335896659422815
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.959Z | Extended Element | 5333606.8373201685,2184678.7262967587,360.98116535078213 | 0.854593 | 180 | -1.14577 | -0.010872828259015527,1.8066786191076133e-10,-0.010735092565822113 | 0.010873191967595617,10.260030926853391,0.21064556117028474
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:34.985Z | Extended Element | 5333606.9636393739,2184688.9909430733,360.98440032433956 | 0.854579 | -0.00047454 | 178.854 | -0.010873038352428886,-2.1703529552472369e-11,-0.010734767183728358 | 0.010872951073567238,9.4983239697849271,0.18829798827228511
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.013Z | Extended Element | 5333607.2430088567,2184688.9951102855,360.98356988696275 | 0.854571 | -0.000873236 | 178.854 | -0.010873058187497944,-1.7624834992500752e-10,-0.010735210852066652 | 0.010872964071565419,8.7367795381817572,0.15782402148696717
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.039Z | Extended Element | 5333607.5223783338,2184688.9992775018,360.9826997644638 | 0.854571 | -0.000873249 | 178.854 | -0.01087303596427169,3.775957235849291e-11,-0.010734767323177311 | 0.010872953464909426,7.9498502948417489,0.12633425784829072
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.068Z | Extended Element | 5333607.8017478138,2184689.0034447145,360.98180917042413 | 0.854578 | -0.000488733 | 178.854 | -0.010873055414109749,-2.0468783298085698e-10,-0.010735210842415521 | 0.010872964817854122,7.1883058655381111,0.09586029110589217
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.096Z | Extended Element | 5333608.0811172938,2184689.0076119262,360.98091857643612 | 0.854579 | -0.000474417 | 178.854 | -0.010873035151299497,-1.1112394166143722e-12,-0.010734767203146433 | 0.010872954276090075,6.4267614354983733,0.065386324292523737
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.121Z | Extended Element | 5333608.3604867738,2184689.0117791444,360.98002798333732 | 0.854578 | -0.000488636 | 178.854 | -0.01087303884965503,1.3488958723640084e-10,-0.010735210918328665 | 0.010872950577470805,5.6651583688410785,0.036054586461760268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.147Z | Extended Element | 5333608.6398562575,2184689.0159463547,360.97913738987722 | 0.854571 | -0.000876334 | 178.854 | -0.010872269097985599,-9.258106440834125e-11,-0.01073521085315363 | 0.010872254065522819,4.877795110106824,0.015238057272733132
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.172Z | Extended Element | 5333608.9192257356,2184689.020113565,360.97823445444658 | -67.5588 | -88.7678 | 111.582 | -0.0095250009566752343,3.7205727672162024e-11,-0.0095249998098501862 | 0.0095250000031975122,4.115631108806868,0.0095250011438529261
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.199Z | Extended Element | 5333609.1985952184,2184689.0242807753,360.9772837046151 | -67.5588 | -88.7678 | 111.582 | -0.0095250000031661449,2.9959288468135974e-11,-0.0095249998824654333 | 0.0095249999983558729,3.353477199584411,0.0095250001175431667
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.225Z | Extended Element | 5333609.4779646974,2184689.0284479838,360.97633295506785 | -67.5588 | -88.7678 | 111.582 | -0.0095250000005175813,1.1657719681726852e-10,-0.0095250001955375918 | 0.0095250000011242331,2.5913232904646413,0.0095249998044744065
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.252Z | Extended Element | 5333609.7573341783,2184689.032615195,360.97538220508011 | -67.5588 | -88.7678 | 111.582 | -0.0095250009534048677,2.436577921028166e-11,-0.0095250007718907046 | 0.0095250000027983575,1.8291693802322175,0.0095250001818097691
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.279Z | Extended Element | 5333610.0367036574,2184689.0367824049,360.97443145544605 | -67.5588 | -88.7678 | 111.582 | -0.0095250000033610359,-3.6725459609003992e-11,-0.0095250004824031786 | 0.0095249999974684266,1.0670154716601425,0.0095249995176113766
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.330Z | Complex Chain | 5333550.9301429987,2184689.5014720261,360.81734031015873 | 0 | 0 | 0 | 0,-13.51132396236062,-0.0066058585319410668 | 0.20154145732522011,0,0.1187443852246588
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.339Z | Complex Chain | 5333550.6621386344,2184688.735388068,360.83135087392895 | 0 | 0 | 0 | 0,-12.749407195486128,-0.021845784717243077 | 0.19017633888870478,0,0.10350445903929995
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.350Z | Complex Chain | 5333550.3941342719,2184687.9693040908,360.8453614371677 | 0 | 0 | 0 | 0,-11.987490429077297,-0.037085710902545088 | 0.17881121952086687,0,0.088264532854054778
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.361Z | Complex Chain | 5333550.1261299094,2184687.2032201043,360.85937200097885 | 0 | 0 | 0 | 0,-11.225573661737144,-0.052325637087847099 | 0.16744609922170639,0,0.073024606668752767
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.369Z | Complex Chain | 5333549.858504382,2184686.4117388986,360.87389056095805 | 0 | 0 | 0 | 0,-10.438259669113904,-0.068073558780554322 | 0.15570214297622442,0,0.057276684975988701
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.380Z | Complex Chain | 5333549.5905000214,2184685.6456549168,360.88790112453154 | 0 | 0 | 0 | 0,-9.6763429013080895,-0.083313484965856333 | 0.14433702174574137,0,0.04203675879068669
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.388Z | Complex Chain | 5333549.3224956589,2184684.8795709345,360.90191168836304 | 0 | 0 | 0 | 0,-8.9144261348992586,-0.098553411151158343 | 0.13297190517187119,0,0.026796832605441523
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.399Z | Complex Chain | 5333549.0544912992,2184684.1134869545,360.91592225163117 | 0 | 0 | 0 | 0,-8.1525093680247664,-0.11379333733640351 | 0.1216067848727107,0,0.011556906420139512
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.410Z | Complex Chain | 5333548.7864869703,2184683.3474005279,360.92554472041218 | 0 | 0 | 0 | 0,-7.3905901559628546,-0.12464516916520552 | 0.11024163197726011,0,0.00070507459139435014
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.420Z | Complex Chain | 5333548.5188614996,2184682.5559161375,360.92171318477841 | 0 | 0 | 0 | 0,-6.603272978682071,-0.12204299521971507 | 0.098497624509036541,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.430Z | Complex Chain | 5333548.2508570598,2184681.7898377962,360.90664584309417 | 0 | 0 | 0 | 0,-5.8413618491031229,-0.10820501572356989 | 0.087132585234940052,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.439Z | Complex Chain | 5333547.9828527002,2184681.0237538218,360.89017634539306 | 0 | 0 | 0 | 0,-5.0794450864195824,-0.092964880948670725 | 0.075767464004456997,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.449Z | Complex Chain | 5333547.7148483396,2184680.2576698475,360.87370684807655 | 0 | 0 | 0 | 0,-4.3175283232703805,-0.077724746173885251 | 0.064402344636619091,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.460Z | Complex Chain | 5333547.4472228149,2184679.4661886478,360.8567293449521 | 0 | 0 | 0 | 0,-3.5302143348380923,-0.061976605890549763 | 0.052658387459814548,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.469Z | Complex Chain | 5333547.1792184543,2184678.7001046729,360.84025984785472 | 0 | 0 | 0 | 0,-2.7682975721545517,-0.046736471115707445 | 0.041293266229331493,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.480Z | Complex Chain | 5333546.9112140937,2184677.9340206981,360.82379035053992 | 0 | 0 | 0 | 0,-2.0063808094710112,-0.031496336340808284 | 0.029928146861493587,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.488Z | Complex Chain | 5333546.643209734,2184677.1679367232,360.80732085390952 | 0 | 0 | 0 | 0,-1.2444640463218093,-0.016256201566079653 | 0.018563027493655682,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.500Z | Complex Chain | 5333546.3752053725,2184676.4018527507,360.79085135683908 | 0 | 0 | 0 | 0,-0.48254728410393,-0.001016066791294179 | 0.0071979071944952011,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.530Z | Extended Element | 5333550.9301429987,2184689.5014720256,360.81734031016691 | 0.85457 | -0.000917674 | 178.854 | -0.010873950359456399,1.8335799032122532e-10,-0.010735101091234826 | 0.010879006722838917,13.510183677017659,0.28632828713463798
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.560Z | Extended Element | 5333550.6621386353,2184688.735388068,360.83135087392736 | 0.85457 | -0.000922876 | 178.854 | -0.010873898858913251,-1.9907453409810087e-10,-0.010735101022846937 | 0.010879058221774559,12.748029767428761,0.28632828689360595
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.589Z | Extended Element | 5333550.3941342738,2184687.9693040908,360.84536143717156 | 0.854586 | -0.00011424 | 178.854 | -0.01087410642171302,1.7303314280852411e-10,-0.010735092437326874 | 0.010878841498147759,11.985875861507816,0.28632828653357179
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.620Z | Extended Element | 5333550.1261299103,2184687.2032201048,360.85937200097084 | 0.854585 | -0.000138391 | 178.854 | -0.010875817392592005,-2.2776447885132148e-11,-0.010735101104177545 | 0.010877131068383755,11.223721951101199,0.28632828606770083
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.650Z | Extended Element | 5333549.8585043829,2184686.4117388991,360.87389056094821 | 0.854578 | -0.000522142 | 178.854 | -0.010875772592444873,1.3044971308116855e-10,-0.010735100986237799 | 0.010877183948980129,10.43616291052729,0.28632829211949767
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.680Z | Extended Element | 5333549.5905000223,2184685.6456549172,360.88790112453421 | 0.854579 | -0.000436015 | 178.854 | -0.010874410864501131,-3.0704328934535439e-11,-0.010735092346376447 | 0.010878535587647353,9.6740090018268923,0.28632829378619701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.709Z | Extended Element | 5333549.176098085,2184675.9609775869,360.80212891429483 | 0.854588 | 0.00000395995 | 0.00000806983 | -0.01087459929277544,-7.1880248241631464e-10,-0.010874635521914332 | 0.010874601343573733,8.1536067572919926,0.13622235141211628
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.736Z | Extended Element | 5333549.3224956617,2184684.8795709345,360.90191168836446 | 0.854577 | -0.000551233 | 178.854 | -0.010875657132230925,1.5618586493895799e-10,-0.01073510089033374 | 0.010877299431755734,8.9118550923929938,0.28632829813031707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.759Z | Extended Element | 5333548.8967286013,2184675.956810372,360.80089955124714 | 0.854588 | 0.00000976752 | 0.00000821966 | -0.010874593828579601,-9.3397835466775415e-11,-0.010874591195494233 | 0.010874595084307161,7.391478438779246,0.13622155618796733
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.785Z | Extended Element | 5333548.6173591241,2184675.9526431588,360.7996701895587 | 0.854588 | 0.0000102357 | 0.00000319761 | -0.010874600384511292,-6.0429733981671261e-10,-0.010874634189391648 | 0.010874598735401825,6.6041233801982848,0.1319891653614999
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.812Z | Extended Element | 5333548.2508570608,2184681.7898377962,360.90664584310167 | -179.145 | -0.00000978608 | -1.14577 | -0.010874597247688788,1.7354548692235697e-10,-0.010874596813858635 | 0.010874592959901853,5.8431977456923043,0.018157384288883339
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.837Z | Extended Element | 5333547.9828526992,2184681.0237538218,360.89017634540153 | -179.145 | -0.00000929163 | -1.14577 | -0.01087459622718436,-1.8943694161411381e-10,-0.010874596833534467 | 0.010874594859653875,5.0810438358832934,0.018157384279561189
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.866Z | Extended Element | 5333547.7148483396,2184680.2576698475,360.87370684808224 | -179.145 | -0.0000022854 | -1.14577 | -0.010874595254226654,-3.3245098921601715e-12,-0.010874598151999803 | 0.010874596945760092,4.318889926335868,0.018157382968859215
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.894Z | Extended Element | 5333547.4472228149,2184679.4661886482,360.85672934496426 | -179.145 | -0.00000984777 | -1.14577 | -0.01087459821425356,1.828671606738691e-10,-0.010874596881016043 | 0.010874593975952735,3.5313308872155518,0.018157384039999277
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.923Z | Extended Element | 5333547.1792184534,2184678.7001046725,360.84025984785177 | -179.145 | -0.00000765986 | -1.14577 | -0.010874596170358727,8.7767489468824299e-11,-0.010874598155025478 | 0.010874596034873608,2.769176978577859,0.018157382553247742
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.951Z | Extended Element | 5333546.9112140955,2184677.9340206985,360.82379035055385 | -179.145 | -0.00000689332 | -1.14577 | -0.010874593058198236,5.8559116115877647e-12,-0.010874557774501014 | 0.010874594070509856,2.0070230713789181,0.018157430357451914
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:35.980Z | Extended Element | 5333546.643209734,2184677.1679367232,360.80732085391321 | -179.145 | -0.0000174691 | -1.14577 | -0.010874592773915304,-4.6018408698425089e-10,-0.010874557790005972 | 0.010874594367300797,1.2448691616180334,0.018157439037768171
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.007Z | Extended Element | 5333546.3824032797,2184675.9193054661,360.78983529004773 | 0.854588 | -0.0000752808 | 0.00000806643 | -0.010874593933538483,1.6627826438262485e-10,-0.010874592465204381 | 0.010874596349969108,0.48279142693784155,0.010886019589927274
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.017Z | Complex Chain | 5333606.2337722313,2184691.0884947833,360.86404845732807 | 0 | 0 | 0 | 0,-13.511323966085911,-5.8822251958190463e-08 | 0.20154145918786526,0,0.12534829916211265
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.028Z | Complex Chain | 5333606.5131417112,2184691.0926619847,360.8632180206277 | 0 | 0 | 0 | 0,-12.749407202471048,-5.8822251958190463e-08 | 0.19017633888870478,0,0.12534829916211265
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.037Z | Complex Chain | 5333606.7925111912,2184691.0968291992,360.86238758402794 | 0 | 0 | 0 | 0,-11.987490438856184,-5.8822251958190463e-08 | 0.17881121952086687,0,0.12534829916205581
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.048Z | Complex Chain | 5333607.0718806721,2184691.1009964142,360.86155714571345 | 0 | 0 | 0 | 0,-11.225573677103966,-5.8822308801609324e-08 | 0.16744609922170639,0,0.12534829916205581
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.056Z | Complex Chain | 5333607.351250153,2184691.1051636273,360.86071710109013 | 0 | 0 | 0 | 0,-10.438259688671678,-5.8822251958190463e-08 | 0.15570214111357927,0,0.12534829916211265
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.068Z | Complex Chain | 5333607.6306196321,2184691.1093308413,360.85982650759718 | 0 | 0 | 0 | 0,-9.6763429259881377,-5.8822251958190463e-08 | 0.14433702174574137,0,0.12534829916205581
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.076Z | Complex Chain | 5333607.9099891121,2184691.1134980549,360.85893591429181 | 0 | 0 | 0 | 0,-8.9144261633045971,-5.8822251958190463e-08 | 0.13297190144658089,0,0.12534829916211265
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.085Z | Complex Chain | 5333608.189358593,2184691.1176652699,360.85804532055585 | 0 | 0 | 0 | 0,-8.1525094010867178,-5.8822251958190463e-08 | 0.12160678207874298,0,0.12534829916211265
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.096Z | Complex Chain | 5333608.4687280729,2184691.121832483,360.85715472679686 | 0 | 0 | 0 | 0,-7.3905901908874512,-5.8822251958190463e-08 | 0.11024162545800209,0,0.12534829916211265
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.105Z | Complex Chain | 5333608.7480975511,2184691.1259996989,360.8562641334164 | 0 | 0 | 0 | 0,-6.6032730136066675,-5.8822308801609324e-08 | 0.098497621715068817,0,0.122041195958559
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.116Z | Complex Chain | 5333609.0274670338,2184691.130166912,360.85533111994027 | 0 | 0 | 0 | 0,-5.8413618798367679,-5.8822308801609324e-08 | 0.087132581509649754,0,0.10820341709325021
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.127Z | Complex Chain | 5333609.3068365157,2184691.1343341246,360.85438037054234 | 0 | 0 | 0 | 0,-5.0794451124966145,-5.8822308801609324e-08 | 0.075767464004456997,0,0.092963490907891355
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.137Z | Complex Chain | 5333609.5862060003,2184691.1385013405,360.85342962069808 | 0 | 0 | 0 | 0,-4.3175283460877836,-5.8822251958190463e-08 | 0.064402343705296516,0,0.077723564722703031
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.150Z | Complex Chain | 5333609.8655754831,2184691.1426685536,360.8524788713504 | 0 | 0 | 0 | 0,-3.5302143534645438,-5.8822251958190463e-08 | 0.052658386528491974,0,0.061975639981824315
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.162Z | Complex Chain | 5333610.1449449612,2184691.1468357625,360.85152812125773 | 0 | 0 | 0 | 0,-2.7682975865900517,-5.8822308801609324e-08 | 0.041293268091976643,0,0.046735713796522305
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.172Z | Complex Chain | 5333610.424314444,2184691.1510029729,360.85056229518887 | 0 | 0 | 0 | 0,-2.0063808192498982,-5.8822251958190463e-08 | 0.029928145930171013,0,0.031495786345601573
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.181Z | Complex Chain | 5333610.7036839379,2184691.1551701967,360.84955139321585 | 0 | 0 | 0 | 0,-1.2444640519097447,-5.8822251958190463e-08 | 0.018563027493655682,0,0.016255860772844244
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.190Z | Complex Chain | 5333610.7036839379,2184691.1551701957,360.85869540743045 | 0 | 0 | 0 | 0,-0.48254728456959128,-5.8822251958190463e-08 | 0.0071979090571403503,0,0.0010159351999163846
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.199Z | Complex Chain | 5333610.9830534197,2184691.1593374065,360.84854048280732 | 0 | 0 | 0 | 0,-0.48254728503525257,-5.8822251958190463e-08 | 0.0071979090571403503,0,0.001015935199973228
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.225Z | Extended Element | 5333606.4353136914,2184677.5771708176,360.87065062722837 | 0.854593 | 180 | -1.14577 | -0.010873950359456399,1.8335799032122532e-10,-0.010735101091234826 | 0.010879006722838917,13.510183677017659,0.28632828713463798
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.250Z | Extended Element | 5333606.7033180501,2184678.3432547827,360.88506032532155 | 0.854593 | 180 | -1.14577 | -0.010873898858913251,-1.9907453409810087e-10,-0.010735101022846937 | 0.010879058221774559,12.748029767428761,0.28632828689360595
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:36.276Z | Extended Element | 5333606.9713224117,2184679.1093387608,360.89947002349692 | 0.854593 | 180 | -1.14577 | -0.01087410642171302,1.7303314280852411e-10,-0.010735092437326874 | 0.010878841498147759,11.985875861507816,0.28632828653357179
