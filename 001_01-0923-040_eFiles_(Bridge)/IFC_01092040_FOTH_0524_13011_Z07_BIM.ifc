Properties of the parts of a building model (IFC4X3_ADD2), part 23 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.258Z | Extended Element | 5333596.5834250757,2184677.2777978182,360.96084500393096 | -89.1454 | -0.000172744 | 179.916 | -0.0093043145852124455,1.447161279474144e-10,-0.0079375000007389715 | 0.0093038270026563497,10.872107044313589,0.030906524285692596
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.270Z | Extended Element | 5333586.7709783027,2184677.1314304816,360.96929703863481 | -89.1454 | 0.0000892398 | -179.996 | -0.0093050940485471315,-6.5700343423818517e-10,-0.0079375000000582122 | 0.0093072336065552711,10.92220945290404,0.030001002621677986
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.282Z | Extended Element | 5333576.9585294724,2184676.9850631165,360.96379572324838 | -89.1454 | -0.0000793941 | -179.924 | -0.0093038109612935994,-5.709853823222625e-11,-0.0079375000001136887 | 0.009303891593940716,10.592756387565876,0.030701994851425964
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.295Z | Extended Element | 5333567.1460970975,2184676.838695995,360.94498938347436 | -89.1454 | -0.000109926 | -179.837 | -0.0093038680473670164,-3.0860168340058524e-10,-0.0079375000009921873 | 0.0093039514389442364,9.92328442432032,0.029797185121924662
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.307Z | Extended Element | 5333546.4129975569,2184676.5294307726,360.86479908407398 | -89.1454 | -180 | -0.251544 | -0.0079375005992022019,-6.9126994022489363e-10,-0.0079375000048385377 | 0.0079374998780424762,10.922023837212674,0.0083581240296116757
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.364Z | Extended Element | 5333595.4209451862,2184676.9810260097,360.94307942294472 | -89.1454 | 0.000172965 | -0.0839428 | -0.0093042262031142482,2.6037285096354416e-10,-0.0093042252659189806 | 0.0093042256978817205,10.922230553795591,0.025205147265868765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.378Z | Extended Element | 5333596.5268681375,2184676.9975225562,360.95735991791469 | -89.1454 | -0.000150207 | 179.916 | -0.0093038682379615392,-2.1744668076647724e-10,-0.0079375000046460649 | 0.0093038215470570718,10.811376072618204,0.031004134268069937
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.391Z | Extended Element | 5333586.7117659068,2184676.8511156095,360.96571823239697 | -89.1454 | 0.000148272 | -179.996 | -0.0093053038670726299,2.5626282212797098e-10,-0.0079375000009209752 | 0.009305072016135502,10.922209402317655,0.030080808038889503
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.406Z | Extended Element | 5333576.8966617417,2184676.7047086349,360.9601335691072 | -89.1454 | -0.0000664024 | -179.924 | -0.0093038111429543276,-1.2076018081983648e-11,-0.0079375000018234408 | 0.0093038448001507967,10.526714036843218,0.03080553096604333
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.420Z | Extended Element | 5333567.0815741904,2184676.558301908,360.94122015064283 | -89.1454 | -0.000139835 | -179.837 | -0.009303942327917817,-3.7280204934212685e-10,-0.0079375000017564111 | 0.0093038852187333765,9.8545863823402637,0.029889360439191076
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.431Z | Extended Element | 5333546.3458196735,2184676.2489970815,360.8609110691736 | -89.1454 | -180 | -0.251549 | -0.0079374999150303768,-4.3509461349639066e-10,-0.0079375000020211837 | 0.0079375003275183893,10.922023837101802,0.0083398688134113854
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.482Z | Extended Element | 5333595.4243547246,2184676.7524509802,360.94307942279744 | -89.1454 | 0.000171247 | -0.0839428 | -0.0093042262031142482,2.6037285096354416e-10,-0.0093042252659189806 | 0.0093042256978817205,10.922230553795591,0.025205147265868765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.492Z | Extended Element | 5333596.5302776778,2184676.7689475249,360.95735991776803 | -89.1454 | -0.0000503698 | 179.916 | -0.0093038682379615392,-2.1744668076647724e-10,-0.0079375000046460649 | 0.0093038215470570718,10.811376072618204,0.031004134268069937
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.503Z | Extended Element | 5333586.7151754452,2184676.6225405796,360.9657182322502 | -89.1454 | 0.000148272 | -179.996 | -0.0093053038670726299,2.5626282212797098e-10,-0.0079375000009209752 | 0.009305072016135502,10.922209402317655,0.030080808038889503
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.513Z | Extended Element | 5333576.9000712819,2184676.476133605,360.96013356896071 | -89.1454 | -0.0000664024 | -179.924 | -0.0093038111429543276,-1.2076018081983648e-11,-0.0079375000018234408 | 0.0093038448001507967,10.526714036843218,0.03080553096604333
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.523Z | Extended Element | 5333567.0849837298,2184676.3297268786,360.94122015049373 | -89.1454 | -0.000138141 | -179.837 | -0.009303942327917817,-3.7280204934212685e-10,-0.0079375000017564111 | 0.0093038852187333765,9.8545863823402637,0.029889360439191076
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.534Z | Extended Element | 5333546.3492292119,2184676.0204220517,360.86091106901688 | -89.1454 | -180 | -0.251549 | -0.0079374999150303768,-4.3509461349639066e-10,-0.0079375000020211837 | 0.0079375003275183893,10.922023837101802,0.0083398688134113854
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.590Z | Extended Element | 5333602.452491683,2184690.9050769676,360.87674568112453 | 90.8546 | 0.000315687 | 0.120951 | -0.0093042257398547185,-8.5650814680398799,-0.0093042252143037615 | 0.0093042256656756805,1.2394349578998423,0.025205146827949935
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.604Z | Extended Element | 5333601.201546574,2184690.8864171617,360.89528766759764 | -89.1454 | -0.000121219 | 179.879 | -0.0093038171015341412,5.6184012993326892e-10,-0.0079375000002273721 | 0.0093038735491401368,10.65635514500504,0.030610126210749631
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.619Z | Extended Element | 5333591.3864566162,2184690.7400103989,360.91038520924172 | -89.1454 | -0.0000770668 | 179.965 | -0.0093038702008705846,-2.0080990139600992e-10,-0.0079375000005731059 | 0.0093038977309521757,9.9841795394516382,0.029721959386370785
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.634Z | Extended Element | 5333581.5713551538,2184690.5936034638,360.91160799163112 | -89.1454 | 0.000133332 | -179.961 | -0.0093039470329601363,-6.9935635139781788e-11,-0.0079375000030437789 | 0.0093038119298971059,10.836017701020895,0.030339366208013023
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.646Z | Extended Element | 5333571.7562609995,2184690.4471966387,360.89950120358066 | -89.1454 | 0.000102761 | -179.874 | -0.0093039204759599592,6.3202467640436791e-10,-0.0079374999998912919 | 0.0093038734384145051,10.163876233622,0.029489816468078172
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.659Z | Extended Element | 5333551.020476413,2184690.1378913647,360.82942944576064 | -89.1454 | 180 | -0.2521 | -0.0079375354139807706,1.946030002738741e-10,-0.007937500000056847 | 0.0079374998719690046,10.922027710583343,0.011942304249204904
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.710Z | Extended Element | 5333602.4547647079,2184690.7526935874,360.87674568140113 | 90.8546 | 0.000214139 | 0.120951 | -0.0093042257398547185,-8.5650814680398799,-0.0093042252143037615 | 0.0093042256656756805,1.2394349578998423,0.025205146827949935
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.718Z | Extended Element | 5333601.2038195999,2184690.734033809,360.89528766787583 | -89.1454 | -0.0000448136 | 179.879 | -0.0093038171015341412,5.6184012993326892e-10,-0.0079375000002273721 | 0.0093038735491401368,10.65635514500504,0.030610126210749631
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.727Z | Extended Element | 5333591.3887296421,2184690.5876270463,360.91038520951815 | -89.1454 | -0.0000786678 | 179.965 | -0.0093038702008705846,-2.0080990139600992e-10,-0.0079375000005731059 | 0.0093038977309521757,9.9841795394516382,0.029721959386370785
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.738Z | Extended Element | 5333581.5736281788,2184690.4412201117,360.91160799190618 | -89.1454 | 0.000214349 | -179.961 | -0.0093039470329601363,-6.9935635139781788e-11,-0.0079375000030437789 | 0.0093038119298971059,10.836017701020895,0.030339366208013023
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.747Z | Extended Element | 5333571.7585340235,2184690.2948132856,360.89950120384947 | -89.1454 | 0.0000538803 | -179.874 | -0.0093039204759599592,6.3202467640436791e-10,-0.0079374999998912919 | 0.0093038734384145051,10.163876233622,0.029489816468078172
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.758Z | Extended Element | 5333551.0227494342,2184689.9855080107,360.82942944603786 | -89.1454 | 179.999 | -0.2521 | -0.0079375354139807706,1.946030002738741e-10,-0.007937500000056847 | 0.0079374998719690046,10.922027710583343,0.011942304249204904
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.821Z | Extended Element | 5333602.4379799841,2184690.5492201503,360.87707236551745 | 90.8546 | 0.0000112676 | 0.120951 | -0.0093042250428566221,-8.5597702718746103,-0.0093042252964386507 | 0.0093042258619615795,1.2196575167128798,0.025205147169835553
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.835Z | Extended Element | 5333601.1843795637,2184690.5305208205,360.89561995794094 | -89.1454 | -0.000146403 | 179.879 | -0.0093038066608208993,-2.4435497067588489e-10,-0.0079375000013270393 | 0.0093038647619273114,10.633922091183457,0.030639933291168858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.849Z | Extended Element | 5333591.3719448745,2184690.3841536655,360.91068202585558 | -89.1454 | -0.000172214 | 179.965 | -0.0093038648597665967,-5.5098394580816599e-10,-0.0079375000021938043 | 0.0093039685390272509,9.9644020961701223,0.029744078016097016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.864Z | Extended Element | 5333581.5594987292,2184690.2377863387,360.9118810342033 | -89.1454 | 0.0000832495 | -179.961 | -0.0093039016526754049,8.4656170599539753e-11,-0.007937500000010915 | 0.0093038127532483039,10.81889586832567,0.030361168524980723
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.880Z | Extended Element | 5333571.7470599217,2184690.0914191208,360.89975421005983 | -89.1454 | 0.0000745331 | -179.874 | -0.0093039492978692281,5.2430301684074893e-10,-0.0079375000010984877 | 0.0093038713459726724,10.14941001552042,0.029505073415764707
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.895Z | Extended Element | 5333551.0139307296,2184689.7821534551,360.82966215207756 | -89.1454 | 179.999 | -0.2521 | -0.0079375378261471279,-8.2642507370938888e-11,-0.0079375000022683575 | 0.0079375003222349576,10.922027717936022,0.011931520464028029
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.954Z | Extended Element | 5333599.9960027412,2184690.2841687868,360.88674593650813 | -89.1454 | -0.000972412 | -0.120951 | -0.0093042256996516762,-2.5771717381084116e-10,-0.0093042250606327984 | 0.0093042250940483535,10.922230324358425,0.025205146822541998
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.970Z | Extended Element | 5333601.104594185,2184690.3007048145,360.90030640569142 | -89.1454 | -0.000146414 | 179.879 | -0.0093039314030553925,-1.9819005641936715e-10,-0.0079374999989768186 | 0.0093038083090049191,10.550752362946433,0.030765295189969892
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.987Z | Extended Element | 5333591.2921592733,2184690.1543376558,360.91524307404922 | -89.1454 | 0.0000251258 | 179.965 | -0.0093038779916816538,3.6437656339539792e-10,-0.0079375000000568453 | 0.009303938931568688,9.881197686530772,0.029851563471852263
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:05.999Z | Extended Element | 5333581.4797130814,2184690.007970328,360.91633459662762 | -89.1454 | 0.0000580905 | -179.961 | -0.0093038854904238175,-9.838506609383567e-11,-0.0079375000014163567 | 0.0093038135862152389,10.735691406092457,0.030486568335555752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.014Z | Extended Element | 5333571.6672744015,2184689.8616031129,360.90408237266996 | -89.1454 | -0.0000271207 | -179.874 | -0.0093039149999651558,-5.5992499535555427e-10,-0.0079375000026931323 | 0.0093038786564576328,10.066205498978235,0.029612558362880136
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.028Z | Extended Element | 5333550.9341457617,2184689.5523374556,360.83380685990767 | -89.1454 | 180 | -0.2521 | -0.0079375112222556075,4.8147432769273813e-12,-0.0079375000022473725 | 0.0079375004569584521,10.922027750447883,0.011855549865357723
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.086Z | Extended Element | 5333599.7682821201,2184689.6282353373,360.90029654122714 | -89.1454 | -0.0000263038 | -0.120951 | -0.0093042259270004913,3.154538511574359e-10,-0.0093042250317617974 | 0.0093042250344313321,10.922230594819514,0.025205147238820804
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.099Z | Extended Element | 5333600.8768734112,2184689.6447716299,360.91385701073199 | -89.1454 | -0.0000619873 | 179.879 | -0.0093038107386063974,-5.3304781369473755e-10,-0.0079375000010501497 | 0.0093038255150396341,10.313238624937457,0.031123245206830182
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.112Z | Extended Element | 5333591.0644378681,2184689.4984044619,360.92843576785884 | -89.1454 | -0.000111069 | 179.965 | -0.0093051628699672116,-3.9810177972443979e-10,-0.0079375000010450114 | 0.0093051122327768299,10.9222089047936,0.030411890688683121
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.124Z | Extended Element | 5333581.2519915383,2184689.3520371318,360.9292205081432 | -89.1454 | 0.000143179 | -179.961 | -0.0093038667802267695,7.3543248621689179e-10,-0.0079375000027381432 | 0.0093038065129915862,10.498212003432116,0.030844480671475005
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.138Z | Extended Element | 5333571.4395532254,2184689.2056699223,360.91661037220933 | -89.1454 | 0.0000759944 | -179.874 | -0.0093040320759659456,-5.2259875759243457e-10,-0.007937500003628967 | 0.009303870915578407,9.8287259457932947,0.029919339196670048
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.153Z | Extended Element | 5333550.7064261651,2184688.8964042882,360.8458112489605 | -89.1454 | 180 | -0.2521 | -0.0079375074165882655,6.0404340692250504e-10,-0.0079375000039526664 | 0.0079375002081805285,10.922027849275592,0.011638717088029795
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.208Z | Extended Element | 5333602.0284930682,2184689.3697107066,360.90187683640255 | 90.8546 | -0.000487374 | 0.108615 | -0.009304225939874896,-8.5597711971961097,-0.0093042251231942857 | 0.0093042255176309964,2.3166250257153678,0.025205147189004063
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.222Z | Extended Element | 5333600.7748889476,2184689.3510114537,360.92015449299112 | -89.1454 | 0.00010901 | 179.891 | -0.0093038904617885314,-1.8288318214794627e-10,-0.0079375000012925981 | 0.0093038695067736484,10.206882986796119,0.029430827655781047
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.236Z | Extended Element | 5333590.9624526612,2184689.2046442749,360.93434412475318 | -89.1454 | -0.0000537164 | 179.965 | -0.0093051449649114142,-4.1677238302072562e-10,-0.0079375000009301779 | 0.0093051077426288507,10.922208815130046,0.030549283305740735
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.248Z | Extended Element | 5333581.150006271,2184689.0582769453,360.93499147234598 | -89.1454 | 0.00023975 | -179.961 | -0.0093038927594522453,4.0936486417651149e-10,-0.0079375000015734446 | 0.0093037974282711884,10.391856667869151,0.03100477169634348
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.264Z | Extended Element | 5333571.3375681229,2184688.9119097376,360.92222104526638 | -89.1454 | 0.000028853 | -179.874 | -0.0093051081348468952,1.8486290273859017e-10,-0.007937499999943155 | 0.009305813378850206,10.922208972049537,0.030310262296958958
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.277Z | Extended Element | 5333550.6044417676,2184688.6026441143,360.85118742265377 | -89.1454 | 179.999 | -0.2521 | -0.007937535599720413,5.2471602699281623e-10,-0.0079375000039550152 | 0.0079375006530966984,10.92202789497359,0.011541608357116834
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.333Z | Extended Element | 5333601.9265080281,2184689.0759507371,360.90792936577731 | 90.8546 | 0.000308998 | 0.108615 | -0.0093042262471678457,-8.5597714885789475,-0.0093042251723363494 | 0.0093042250954561839,2.2102697567200025,0.025205146828589185
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.346Z | Extended Element | 5333600.6729039792,2184689.0572512723,360.92620702224525 | -89.1454 | 0.0000308438 | 179.891 | -0.0093038802653001018,5.1713200381169207e-10,-0.0079375000006252812 | 0.0093038743589045902,10.100527786727088,0.029568220030247377
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.361Z | Extended Element | 5333590.8604674498,2184688.9108840884,360.94025926181217 | -89.1454 | -0.0000617638 | 179.965 | -0.0093051312772626498,7.2371370002668393e-10,-0.0079374999999431602 | 0.0093051091976652407,10.922208725669689,0.030686675924379476
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.377Z | Extended Element | 5333581.0480209999,2184688.7645167573,360.94076921671592 | -89.1454 | 0.0000544595 | -179.961 | -0.0093038412445649796,2.032668477670845e-10,-0.0079375000000568418 | 0.0093038123904941039,10.285501330518578,0.031165062548731338
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.390Z | Extended Element | 5333571.2355830194,2184688.6181495525,360.92783849848325 | -89.1454 | 0.0000985852 | -179.874 | -0.0093052649677570539,-5.7120308891068523e-11,-0.007937500003033145 | 0.0093050974428163964,10.922208884072754,0.030447653967335567
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.408Z | Extended Element | 5333550.5024573701,2184688.3088839399,360.85657037650458 | -89.1454 | 180 | -0.2521 | -0.0079375096992311111,8.2857199807271558e-10,-0.0079375000014522794 | 0.0079375000767619164,10.922027938192217,0.011444499618233616
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.473Z | Extended Element | 5333610.3833263414,2184688.9098578361,360.90449705195755 | -89.1454 | -0.0000801138 | 179.805 | -0.0093038178627714123,2.444933542180989e-10,-0.0079375000002790026 | 0.0093038239283205187,10.663684579021892,0.030595061859875899
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.489Z | Extended Element | 5333600.5709190136,2184688.7634910885,360.93228126426351 | -89.1454 | 0.000109185 | 179.891 | -0.0093038822597601312,-6.3122681616772775e-10,-0.0079375000010813244 | 0.0093039077517147045,9.9941725867193636,0.029705612521198268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.505Z | Extended Element | 5333590.7584822485,2184688.6171239023,360.94619611164245 | -89.1454 | -0.0000574841 | 179.965 | -0.0093038129932393483,-1.6138238589071451e-10,-0.0079375000028567462 | 0.0093038874691538324,10.848656474872213,0.030316313039341836
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.523Z | Extended Element | 5333580.9460355574,2184688.4707565675,360.94679153734495 | -89.1454 | -0.0000316354 | -179.948 | -0.009303872970681689,-3.2527381121951829e-10,-0.0079375000012155434 | 0.0093039022049641457,10.179145561793163,0.029466667108970838
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.537Z | Extended Element | 5333571.1335979169,2184688.3243893674,360.93347766447607 | -89.1454 | 0.00012231 | -179.874 | -0.0093051895435230826,3.5512748296096335e-10,-0.0079375000001705356 | 0.0093050955850884631,10.922208795790985,0.03058504564725769
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.549Z | Extended Element | 5333550.4004729744,2184688.0151237659,360.8619750431331 | -89.1454 | 179.999 | -0.2521 | -0.007937534916780304,2.424572273697212e-11,-0.0079375000045576408 | 0.0079375003672114176,10.922027982211093,0.011347390901765906
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.609Z | Extended Element | 5333610.2813419448,2184688.6160976612,360.91066781491344 | -89.1454 | -0.0000547437 | 179.805 | -0.0093038531015296293,-2.60170661868267e-11,-0.0079375000009399635 | 0.0093038226496157846,10.557329524848429,0.030755351619259075
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.621Z | Extended Element | 5333600.4689341113,2184688.4697309071,360.93829173798525 | -89.1454 | 0.0000252798 | 179.891 | -0.0093038784974769674,5.3989319285729734e-10,-0.007937500001180528 | 0.0093039474430782251,9.8878174519719799,0.029843005008033052
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.633Z | Extended Element | 5333590.6564970892,2184688.3233637167,360.95206919326296 | -89.1454 | -0.000104875 | 179.965 | -0.009303810230741609,-4.3269736636068581e-10,-0.0079375000015360336 | 0.0093038842887012245,10.742301253805211,0.030476603930995674
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.646Z | Extended Element | 5333580.8440503404,2184688.176996381,360.95250432756296 | -89.1454 | -0.0000545469 | -179.948 | -0.0093038933451790283,-4.518124305807487e-10,-0.0079375000008284052 | 0.0093038802969055198,10.072790258856731,0.029604059592777239
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.659Z | Extended Element | 5333571.0316128293,2184688.0306291836,360.93905306231545 | -89.1454 | 0.0000288851 | -179.874 | -0.0093051328701767057,1.7382620251436042e-10,-0.0079375000010043911 | 0.0093051015723315811,10.922208705010163,0.030722437310773371
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.671Z | Extended Element | 5333550.2984885778,2184687.721363592,360.86731594157698 | -89.1454 | 179.999 | -0.2521 | -0.0079375320816574731,2.8620547775855433e-10,-0.0079374999991533683 | 0.0079375005828017063,10.922028028248938,0.011250282180741238
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.724Z | Extended Element | 5333610.1793575482,2184688.3223374877,360.91693825264031 | -89.1454 | -0.00012811 | 179.805 | -0.0093038074693310088,2.5102564468179685e-10,-0.0079375000003410624 | 0.0093038485202944967,10.45097447122378,0.03091564140261472
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.738Z | Extended Element | 5333600.3669492062,2184688.1759707252,360.94440188647064 | -89.1454 | 0.0000487762 | 179.891 | -0.0093038794013086384,8.9676575652600255e-11,-0.0079375000003847184 | 0.0093039766362350042,9.7814623136963572,0.029980397607175153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.752Z | Extended Element | 5333590.5545119317,2184688.0296035311,360.95804194964381 | -89.1454 | -0.0000663827 | 179.965 | -0.0093038119322916037,3.9568370800460457e-10,-0.007937499999715783 | 0.0093038784103256431,10.63594603574505,0.030636895303237092
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.764Z | Extended Element | 5333580.7420651224,2184687.883236195,360.95831679254366 | -89.1454 | -0.0000727181 | -179.948 | -0.0093038945662171826,-2.4768845517163356e-10,-0.007937500000738968 | 0.0093038817770551997,9.9664349552957532,0.029741452259998712
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.778Z | Extended Element | 5333570.9296277398,2184687.7368689994,360.94472813492138 | -89.1454 | 0.0000802113 | -179.874 | -0.009303899097159252,-5.2537945651237975e-11,-0.0079375000033324369 | 0.0093038129460997609,10.820961721229319,0.0303580522558889
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.790Z | Extended Element | 5333550.1965041803,2184687.4276034171,360.87275651478717 | -89.1454 | 180 | -0.2521 | -0.0079375086334202705,7.2971945419130449e-10,-0.0079374999995396427 | 0.0079375004275536801,10.922026534311478,0.010936276840726141
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.846Z | Extended Element | 5333610.0773731498,2184688.0285773128,360.92307988839792 | -89.1454 | -0.000105638 | 179.805 | -0.0093038087219667678,3.8756008700279634e-12,-0.0079375000050326897 | 0.009303830730252944,10.344619416121379,0.031075931650641868
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.860Z | Extended Element | 5333600.2649643021,2184687.8822105438,360.95038323299173 | -89.1454 | 0.0000747046 | 179.891 | -0.0093051089384260949,1.6645573802171675e-11,-0.0079375000011368702 | 0.0093051146584636896,10.922208932848873,0.030371331411673513
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.874Z | Extended Element | 5333590.4525267743,2184687.7358433455,360.96388590406315 | -89.1454 | -0.000118913 | 179.965 | -0.0093038091116219475,1.3702480049485983e-10,-0.0079375000001246053 | 0.0093039016444337267,10.529590817552739,0.030797187036552161
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.889Z | Extended Element | 5333580.6400799081,2184687.5894760084,360.96400045556527 | -89.1454 | -0.0000961282 | -179.948 | -0.0093038695083943659,8.4218797746806824e-11,-0.0079375000004469221 | 0.0093040476072201485,9.8600796556788044,0.029878844841898712
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.903Z | Extended Element | 5333570.8276426569,2184687.4431088138,360.95027440557442 | -89.1454 | 0.000223643 | -179.874 | -0.0093038357049515606,4.7963746812240197e-10,-0.0079375000036036453 | 0.0093038031159474177,10.714606339797228,0.030518342802018567
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.913Z | Extended Element | 5333550.0945197828,2184687.1338432427,360.87806828602697 | -89.1454 | 179.999 | -0.2521 | -0.007937529371655162,-2.97813315809226e-10,-0.0079375000002107135 | 0.0079375001932862101,10.922026564755182,0.010862066639574175
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.973Z | Extended Element | 5333601.2758873533,2184687.2018863047,360.94649187047372 | 90.8546 | 0.000262454 | 0.108615 | -0.0093042260465030485,-8.5597716111600057,-0.0093042251265352278 | 0.009304226013414978,1.5317688645539382,0.025205147139974633
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:06.987Z | Extended Element | 5333600.0222838158,2184687.1831868589,360.9647695259689 | -89.1454 | 0.0000364709 | 179.891 | -0.0093051076329366492,5.7950772003846418e-10,-0.0079375000007659777 | 0.0093051402588561205,10.922208722651913,0.030698266209969998
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.003Z | Extended Element | 5333590.2098456826,2184687.0368196517,360.9779452625574 | -89.1454 | -0.0000866642 | 179.965 | -0.0093038101626128529,-5.6710888765447182e-10,-0.0079375000001136904 | 0.0093038590436424207,10.2765108474425,0.031178612264907882
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.016Z | Extended Element | 5333580.3973986777,2184686.8904523132,360.97767838902962 | -89.1454 | -0.0000947541 | -179.948 | -0.009305185353802101,9.2752113592492698e-11,-0.0079375000011229664 | 0.0093051112733956564,10.922208875696928,0.030459320026776687
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.030Z | Extended Element | 5333570.5849617356,2184686.7440851233,360.96362540391306 | -89.1454 | 0.000144242 | -179.874 | -0.0093038451707315468,-3.1044669992174399e-10,-0.0079375000010385357 | 0.0093038064597062604,10.461525976686218,0.030899764972367232
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.043Z | Extended Element | 5333549.8518405044,2184686.4348195768,360.89086127601871 | -89.1454 | 179.999 | -0.2521 | -0.0079375270505055943,1.5137711087172483e-10,-0.0079375000003569993 | 0.0079374996622441421,10.922026626239523,0.010685478070542971
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.093Z | Extended Element | 5333601.1739023654,2184686.9081260329,360.95253761686013 | 90.8546 | -0.0000590105 | 0.108615 | -0.0093042254038083472,-8.5597718985070106,-0.0093042252560057732 | 0.0093042256649078,1.4254136425125903,0.025205146943490998
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.107Z | Extended Element | 5333599.9202989116,2184686.889426677,360.97081527220075 | -89.1454 | 0.0000693398 | 179.891 | -0.0093039209434843586,-4.1727593138750852e-10,-0.0079375000024671221 | 0.0093038133729999254,10.839676030645428,0.030329839781465761
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.121Z | Extended Element | 5333590.1078606322,2184686.7430594671,360.98407454665636 | -89.1454 | 0.000174895 | 179.978 | -0.0093039127511151641,2.7618357794841821e-10,-0.0079375000008557878 | 0.0093038635678837807,10.170155190715215,0.029478281674156066
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.133Z | Extended Element | 5333580.2954134587,2184686.5966921262,360.98342645175586 | -89.1454 | 0.0000257548 | -179.948 | -0.0093051061233334498,9.4761976013972923e-11,-0.0079375000000000018 | 0.0093051351572423953,10.922208787958319,0.030596712366224851
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.146Z | Extended Element | 5333570.4829766471,2184686.4503249391,360.96923607425691 | -89.1454 | 0.000117017 | -179.874 | -0.0093038267213241006,6.2737828362180302e-11,-0.007937500001562587 | 0.0093038314235791963,10.355170590325525,0.031060055234854909
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.157Z | Extended Element | 5333549.7498561097,2184686.1410594024,360.89623744697235 | -89.1454 | 180 | -0.2521 | -0.0079375106039415565,-3.6241729404732133e-10,-0.0079374999979033335 | 0.007937500125839601,10.922026647660237,0.010611267883694882
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.216Z | Extended Element | 5333601.0719173783,2184686.6143658683,360.95858336290473 | 90.8546 | 0.00000631089 | 0.108615 | -0.0093042255532545092,-8.5597721849120774,-0.0093042252354574445 | 0.0093042258577950513,1.3190584214207761,0.025205147567402587
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.231Z | Extended Element | 5333599.8183140056,2184686.5956664947,360.97686101807801 | -89.1454 | 0.0000994715 | 179.891 | -0.0093039015081795556,3.3784312674389583e-10,-0.0079375000019836026 | 0.0093038110414306718,10.733320893576817,0.030490130539704865
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.244Z | Extended Element | 5333590.0058754617,2184686.4492992824,360.98996000167301 | -89.1454 | -0.0000398538 | 179.978 | -0.0093038724878577589,7.8532361064805412e-10,-0.0079375000015487907 | 0.0093039321418294935,10.063799971384126,0.029615674439621438
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.259Z | Extended Element | 5333580.1934282407,2184686.3029319406,360.98917451412746 | -89.1454 | -0.00016306 | -179.948 | -0.0093045226176729865,-4.6246490605573543e-10,-0.0079375000009881715 | 0.0093038424847124573,10.918296040005346,0.030211363429146772
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.272Z | Extended Element | 5333570.3809910091,2184686.1565647465,360.97508459964445 | -89.1454 | -0.000157054 | -179.862 | -0.0093038675019462089,-4.196748504493622e-10,-0.0079375000009094983 | 0.0093039236732713609,10.248814764432245,0.029376660408027479
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.282Z | Extended Element | 5333549.6478717113,2184685.8472992284,360.90161361757515 | -89.1454 | 180 | -0.2521 | -0.0079375210710691015,6.805887163577998e-10,-0.0079375000038060511 | 0.0079375001489387087,10.922026675406055,0.010537057643787861
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.334Z | Extended Element | 5333600.9699323885,2184686.3206058904,360.96462910866489 | 90.8546 | 0.0007595 | 0.108615 | -0.0093042259021023522,-8.5597724716382579,-0.0093042251039917676 | 0.0093042256992168487,1.2127032038129912,0.025205146938986268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.347Z | Extended Element | 5333599.7163291015,2184686.3019063128,360.98290676369606 | -89.1454 | 0.0000560319 | 179.891 | -0.0093038725235520866,-3.2334902742377741e-10,-0.0079375000013017488 | 0.0093038126264553492,10.626965756044456,0.030650421558878396
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.360Z | Extended Element | 5333589.9038902922,2184686.1555390949,360.99584545642887 | -89.1454 | 0.000104168 | 179.978 | -0.009303969019253594,-5.6385451961094805e-10,-0.0079375000006390983 | 0.0093038689791994384,9.9574447482858872,0.029753067138277679
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.372Z | Extended Element | 5333580.0914430227,2184686.0091717532,360.99492257624223 | -89.1454 | -0.0000447909 | -179.948 | -0.0093038137256085847,3.572288020730239e-10,-0.0079374999999431567 | 0.0093038943456743295,10.811940738013117,0.030371652105061455
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.386Z | Extended Element | 5333570.2790059736,2184685.8628045623,360.98067237075878 | -89.1454 | -0.0000393974 | -179.862 | -0.009303872848670125,-4.3519129658113325e-10,-0.0079375000021581574 | 0.0093039247955751178,10.142459379590742,0.029514052046860268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.397Z | Extended Element | 5333549.5458873129,2184685.5535390535,360.90698978790545 | -89.1454 | 179.999 | -0.2521 | -0.0079375238755805613,4.8157090511186689e-10,-0.0079375000042368818 | 0.0079375002023745079,10.922026700002213,0.010462847449557956
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.448Z | Extended Element | 5333598.5057568317,2184685.9916097298,360.97519320536782 | -89.1454 | 0.000571692 | -0.108615 | -0.0093042257914789893,-5.8696214615286822e-11,-0.0093042251167416972 | 0.0093042252903163154,10.9222303589017,0.025205147071154756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.461Z | Extended Element | 5333599.6143441983,2184686.0081461309,360.98899238678763 | -89.1454 | 0.0000120765 | 179.891 | -0.0093038297663093038,1.15183112403262e-10,-0.0079375000003515713 | 0.0093038181910367959,10.520610619610475,0.03081071299651721
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.473Z | Extended Element | 5333589.8019051226,2184685.8617789103,361.00177078865607 | -89.1454 | 0.0000570142 | 179.978 | -0.0093040045646513928,8.2827900628794283e-11,-0.007937500000522504 | 0.0093038722638468848,9.8510895319517466,0.029890460171247381
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.487Z | Extended Element | 5333579.9894578075,2184685.7154115667,361.00071051582995 | -89.1454 | -0.0000753406 | -179.948 | -0.0093038137823580336,2.7465415711507697e-10,-0.0079375000012723834 | 0.009303823561070141,10.705585437027286,0.030531943538973441
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.499Z | Extended Element | 5333570.1770209419,2184685.5690443786,360.98630001935697 | -89.1454 | -0.000128186 | -179.862 | -0.0093038679561265984,-3.5661162916410839e-10,-0.0079374999986926049 | 0.0093039177770947671,10.036103995795642,0.029651443355563311
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.511Z | Extended Element | 5333549.4439029191,2184685.2597788796,360.91240583573125 | -89.1454 | 180 | -0.2521 | -0.0079375096410702513,-2.877427185622447e-10,-0.0079374999996589431 | 0.0079375001340914898,10.922026726889486,0.010388637253677084
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.564Z | Extended Element | 5333598.4037720067,2184685.6978496197,360.98119907259553 | -89.1454 | 0.000319176 | -0.108615 | -0.0093042252864348664,7.3434053642321842e-11,-0.0093042250213478013 | 0.0093042255294534682,10.922230480151692,0.025205146881268316
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.577Z | Extended Element | 5333599.5123592941,2184685.7143859495,360.99499825418116 | -89.1454 | 0.000135714 | 179.891 | -0.0093039046153349982,-1.5151429345419566e-10,-0.0079375000029109407 | 0.0093038078199584283,10.414255482472562,0.030971003847230463
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.591Z | Extended Element | 5333589.6999199521,2184685.5680187237,361.00761636519019 | -89.1454 | 0.0000630555 | 179.978 | -0.0093059187208216852,-2.452713206136609e-10,-0.0079375000018382137 | 0.0093038759210905646,9.7447343098753514,0.03002785820382772
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.605Z | Extended Element | 5333579.8874725876,2184685.4216513811,361.00641869972162 | -89.1454 | -0.000112957 | -179.948 | -0.0093038085450129274,4.7052728374891882e-10,-0.0079375000000000001 | 0.0093038614869856828,10.599230133458779,0.030692234729705996
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.617Z | Extended Element | 5333570.0750359064,2184685.2752841958,360.99184791224422 | -89.1454 | -0.000166667 | -179.862 | -0.0093038663679155184,1.8309098678518346e-10,-0.007937500000568436 | 0.0093040278736403782,9.9297486096011625,0.029788835488510523
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.629Z | Extended Element | 5333549.3419185206,2184684.9660187047,360.91774212784895 | -89.1454 | 180 | -0.2521 | -0.0079375071281606938,-7.5160311842438347e-12,-0.0079375000005140993 | 0.0079375005029387984,10.922026752919635,0.010314427038944928
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.683Z | Extended Element | 5333598.3017871864,2184685.4040895505,360.98724481758785 | -89.1454 | -0.0000755371 | -0.108615 | -0.0093042253361618511,-1.536183912348186e-10,-0.0093042251722850865 | 0.0093042257110305601,10.92223060008652,0.025205147032030341
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.696Z | Extended Element | 5333599.4103743909,2184685.4206257686,361.00104399932911 | -89.1454 | 0.000169654 | 179.891 | -0.0093039136056895927,-4.9474525243928925e-10,-0.0079375000046031253 | 0.0093038026572465522,10.307900345259743,0.031131294859661474
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.711Z | Extended Element | 5333589.5979347816,2184685.2742585386,361.0135018194768 | -89.1454 | 0.0000678851 | 179.978 | -0.0093051091856856862,6.8111938309821093e-10,-0.0079374999997157865 | 0.0093051339415931977,10.922208900149286,0.030418788617741808
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.724Z | Extended Element | 5333579.7854873706,2184685.1278911936,361.01216676136471 | -89.1454 | -0.0000624397 | -179.948 | -0.009303811598629837,6.4950361753072026e-10,-0.0079374999998863167 | 0.009303877199102438,10.492874830827137,0.030852525858796564
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.739Z | Extended Element | 5333569.9730508719,2184684.9815240111,360.99743568289341 | -89.1454 | 0.0000402162 | -179.862 | -0.0093038793002340452,3.1597291799882405e-10,-0.0079375000021531146 | 0.009303947091408445,9.8233932249083651,0.029926226851701543
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.793Z | Extended Element | 5333549.2399341231,2184684.6722585303,360.92311829771177 | -89.1454 | 180 | -0.2521 | -0.0079375062717566246,-4.9474924644750788e-10,-0.0079375000011021254 | 0.0079375004047952964,10.922026778181188,0.010240216822240434
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.850Z | Extended Element | 5333608.9801082145,2184684.8679689341,360.98981751516931 | -89.1454 | 0.0000408726 | 179.817 | -0.0093038349274352644,-2.5508023127748776e-10,-0.0079375000017091329 | 0.0093038136309758108,10.724335733824146,0.030565661317696488
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.863Z | Extended Element | 5333599.1676942548,2184684.7216020892,361.0155923802505 | -89.1454 | 0.0000979236 | 179.904 | -0.0093039075079026437,-2.931544857191793e-10,-0.0079375000007204082 | 0.0093038674079441441,10.054820137645429,0.029627269821689065
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.876Z | Extended Element | 5333589.3552536648,2184684.5752348443,361.02747268097062 | -89.1454 | 0.000121687 | 179.978 | -0.0093038378394571866,2.8612232026676382e-10,-0.0079375000002842207 | 0.0093044131483306144,10.909303230534794,0.030224914600937906
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.888Z | Extended Element | 5333579.5428059017,2184684.4288674938,361.02604660770868 | -89.1454 | 0.000139359 | -179.936 | -0.0093039292768252232,-3.0991815490806208e-10,-0.0079375000011202776 | 0.0093038689967651547,10.239794228183788,0.02938832067545576
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.899Z | Extended Element | 5333569.7303700773,2184684.282500322,361.01069818455687 | -89.1454 | -0.0000547316 | -179.862 | -0.0093050995025274214,7.6410126181684101e-11,-0.0079375000014687645 | 0.0093052103781529009,10.922208845092426,0.030506688286658468
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.911Z | Extended Element | 5333548.9972548466,2184683.9732348644,360.93587727996163 | -89.1454 | 179.999 | -0.2521 | -0.0079375179391568719,-2.060480020193233e-11,-0.0079374999998915955 | 0.0079374999428971811,10.922026840644232,0.010063628269481975
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.965Z | Extended Element | 5333608.878123817,2184684.5742087597,360.99504461977517 | -89.1454 | 0.00007006 | 179.817 | -0.0093038398865135773,-4.9914183510938145e-11,-0.0079375000072596947 | 0.0093038139511379438,10.617980708922273,0.030663947971680337
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.978Z | Extended Element | 5333599.0657093385,2184684.4278419069,361.02064708037216 | -89.1454 | 0.00000629788 | 179.904 | -0.0093039422286765056,2.8976017339593011e-10,-0.0079375000011236846 | 0.0093038750444637275,9.948465029012759,0.029764662106458943
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:07.991Z | Extended Element | 5333589.2532685166,2184684.2814746592,361.03238998891197 | -89.1454 | 0.000102537 | 179.978 | -0.0093038500012975235,-5.5694354687338874e-10,-0.0079374999998863115 | 0.0093038099728491343,10.802948030831459,0.030385204279567687
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.004Z | Extended Element | 5333579.44082072,2184684.1351073077,361.0308036242792 | -89.1454 | 0.0000808035 | -179.936 | -0.0093038807633128492,-3.3644209642196194e-10,-0.0079375000003979023 | 0.0093038841883823949,10.133438937743634,0.029525712696059928
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.014Z | Extended Element | 5333569.6283850484,2184683.9887401382,361.01531780888541 | -89.1454 | -0.000158459 | -179.862 | -0.0093050932244426975,-6.791689834898398e-10,-0.0079375000017652964 | 0.0093051480988014194,10.922208756598197,0.030644079769885892
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.025Z | Extended Element | 5333548.8952704472,2184683.6794746905,360.94028530348197 | -89.1454 | 179.999 | -0.2521 | -0.0079375190765072386,2.3610824825547194e-10,-0.0079375000061100501 | 0.0079375004733121084,10.922026866650443,0.0099894180485698373
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.079Z | Extended Element | 5333608.7761394205,2184684.2804485862,360.99834406337641 | -89.1454 | -0.0000780458 | 179.817 | -0.0093038111979118002,7.6102901754161228e-10,-0.0079375000001705338 | 0.0093038428448702064,10.51162572926181,0.03082423782546349
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.091Z | Extended Element | 5333598.9637244549,2184684.134081726,361.02378623458651 | -89.1454 | -0.00004363 | 179.904 | -0.0093038735273163926,3.704999640280479e-10,-0.0079374999996589431 | 0.0093038872093492899,9.8421099532573706,0.029902054506700904
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.104Z | Extended Element | 5333589.1512833908,2184683.9877144741,361.03539175098808 | -89.1454 | 0.000155858 | 179.978 | -0.0093038791075275764,2.0473927761425649e-10,-0.007937500001559978 | 0.0093038037174757501,10.69659285848339,0.030545495203310999
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.114Z | Extended Element | 5333579.3388355589,2184683.841347123,361.03364509501625 | -89.1454 | 0.0000453851 | -179.936 | -0.0093039135300312121,-1.352923689019624e-10,-0.0079375000008744812 | 0.0093038725955343887,10.027083668512663,0.029663105549908864
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.127Z | Extended Element | 5333569.5264000297,2184683.6949799545,361.01802188737827 | -89.1454 | -0.0000318382 | -179.862 | -0.0093038820773876461,1.0854026444104441e-10,-0.0079374999995543843 | 0.0093038218251391396,10.881616043998847,0.030266640020526047
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.138Z | Extended Element | 5333548.7932860516,2184683.3857145165,360.94277778116782 | -89.1454 | 180 | -0.2521 | -0.0079375063786935145,-5.7906435204957593e-10,-0.0079374999978967971 | 0.0079375000586081081,10.922025318050409,0.0096852524898573475
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.194Z | Extended Element | 5333608.6741550257,2184683.9866884118,360.99965002426075 | -89.1454 | 0.000134005 | 179.817 | -0.0093038685519998433,-8.1203932520995789e-11,-0.0079375000021032101 | 0.0093038061307141925,10.405270751765554,0.030984528572805349
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.205Z | Extended Element | 5333598.8617395703,2184683.8403215441,361.02493190609488 | -89.1454 | 0.0000906035 | 179.904 | -0.009305119889755702,-2.7865141219776079e-11,-0.0079374999993178826 | 0.0093079280630745456,10.92220898239958,0.030292987569445953
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.215Z | Extended Element | 5333589.0492982678,2184683.693954289,361.0364000303619 | -89.1454 | 0.000118079 | 179.978 | -0.0093038660909738405,4.7099914656727361e-11,-0.0079375000012517159 | 0.0093038083808715845,10.590237682353868,0.030705787067806588
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.227Z | Extended Element | 5333579.2368503958,2184683.5475869374,361.03449308304999 | -89.1454 | 0.000120279 | -179.936 | -0.0093039221513786831,7.2490359564920799e-10,-0.0079375000009881697 | 0.0093038692981153564,9.9207283980335177,0.029800497666724306
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.238Z | Extended Element | 5333569.4244150128,2184683.4012197717,361.01873248317474 | -89.1454 | -0.000122212 | -179.862 | -0.0093038742870711916,2.9080382542870781e-10,-0.0079374999998294733 | 0.0093038279943754073,10.77526067556586,0.030426929743067127
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.248Z | Extended Element | 5333548.6913016569,2184683.0919543416,360.9432767761507 | -89.1454 | 179.999 | -0.2521 | -0.0079375149645485848,3.4285774213503289e-10,-0.0079374999991473558 | 0.0079375000558219271,10.922025332323752,0.0096339407572683007
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.296Z | Extended Element | 5333608.5721706264,2184683.6929282369,360.99901877706293 | -89.1454 | 0.0000835589 | 179.817 | -0.0093038487835672128,4.063807161662459e-10,-0.0079375000008428745 | 0.009303812930092227,10.298915772739708,0.031144818437679623
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.311Z | Extended Element | 5333598.7597546857,2184683.5465613622,361.02414036951939 | -89.1454 | 0.00000667495 | 179.904 | -0.0093051325095332652,2.1744878788100409e-11,-0.0079375000021468627 | 0.0093051024484063685,10.922208894711012,0.03043038004654347
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.329Z | Extended Element | 5333588.9473131401,2184683.4001941038,361.03547110164612 | -89.1454 | 0.0000785726 | 179.978 | -0.0093038482348084886,4.7059116180090291e-10,-0.007937500001934935 | 0.0093038105426274213,10.483882508712796,0.030866077814322938
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.340Z | Extended Element | 5333579.134865229,2184683.2538267514,361.03340386299209 | -89.1454 | 0.000161426 | -179.936 | -0.009303887089014343,-5.3796051158721925e-10,-0.007937500000578206 | 0.0093039365688397761,9.8143731235243976,0.029937890344858175
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.352Z | Extended Element | 5333569.3224299913,2184683.107459587,361.01750587087014 | -89.1454 | -0.000060925 | -179.862 | -0.0093038127232185422,-4.9428258251647035e-10,-0.0079375000022074271 | 0.0093038756889344716,10.668905305214158,0.030587220337312943
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.363Z | Extended Element | 5333548.5893172603,2184682.7981941681,360.94183856304079 | -89.1454 | 180 | -0.2521 | -0.0079375140793770359,8.1706308383036326e-10,-0.0079375000004547509 | 0.0079374999873191715,10.922025344242099,0.0095826290506994226
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.420Z | Extended Element | 5333599.9113760693,2184683.2715005996,361.00335423421757 | 90.8546 | 0.0000152033 | 0.0962788 | -0.0093042264966766673,-8.5597738450307634,-0.0093042251547804499 | 0.009304225304993613,1.6327874656205266,0.025205146827426163
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.432Z | Extended Element | 5333598.6577697983,2184683.2528011804,361.02136195154571 | -89.1454 | -0.000147258 | 179.904 | -0.0093050940652883007,-9.3802965443658361e-11,-0.0079374999985789129 | 0.0093052150727120329,10.922208804949801,0.030567772267405126
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.445Z | Extended Element | 5333588.8453280171,2184683.1064339187,361.0325552915354 | -89.1454 | 0.000212996 | 179.978 | -0.009303895858148753,-3.4532071150171648e-10,-0.0079375000015910555 | 0.0093037981172225392,10.37752733287873,0.031026369249796786
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.457Z | Extended Element | 5333579.032880065,2184682.9600665648,361.03032776153873 | -89.1454 | 0.0000936642 | -179.936 | -0.0093051111897500764,3.9953410621470232e-10,-0.0079375000010200418 | 0.0093054195172137949,10.922208960872593,0.030328819951390532
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.470Z | Extended Element | 5333569.2204449708,2184682.8136994047,361.01429237717014 | -89.1454 | -0.0000852165 | -179.862 | -0.0093038098697483008,-3.2023658943904605e-10,-0.0079375000020900244 | 0.0093038281663922681,10.562549932958108,0.030747509950025599
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.481Z | Extended Element | 5333548.4873328619,2184682.5044339933,360.93841346853083 | -89.1454 | 180 | -0.2521 | -0.0079375059986855658,2.5197080909146985e-11,-0.0079375000003156348 | 0.0079375004393107181,10.9220253558483,0.0095313173164059926
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.538Z | Extended Element | 5333599.809391086,2184682.9777404172,360.99865696950047 | 90.8546 | 0.0000203656 | 0.0962788 | -0.0093042263650357834,-8.5597741613440821,-0.0093042251635390739 | 0.0093042255103008408,1.5264322909086596,0.025205146853029783
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.550Z | Extended Element | 5333598.5557849128,2184682.9590409989,361.01666468666212 | -89.1454 | 0.00000345032 | 179.904 | -0.0093051096372564601,5.7458671153243532e-10,-0.0079374999997726316 | 0.0093051029307858902,10.922208716926749,0.030705164492817703
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.562Z | Extended Element | 5333588.7433428913,2184682.8126737336,361.02772063451334 | -89.1454 | 0.0000892783 | 179.978 | -0.0093038659510958563,6.4564524566826955e-10,-0.0079375000016221331 | 0.0093038095700643426,10.271172158851531,0.031186660799635578
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.573Z | Extended Element | 5333578.9308949029,2184682.6663063797,361.02533281317528 | -89.1454 | -0.0000292909 | -179.936 | -0.0093051014245315918,3.2916371322469291e-10,-0.007937500001352904 | 0.0093051401255354899,10.922208871157368,0.030466212106049155
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.585Z | Extended Element | 5333569.1184599521,2184682.5199392196,361.00916003656795 | -89.1454 | -0.000102317 | -179.862 | -0.0093038094493019113,-6.9669270369869192e-11,-0.007937499999886315 | 0.0093038791501015052,10.456194563640782,0.030907800410066678
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.596Z | Extended Element | 5333548.3853484662,2184682.2106738184,360.93306952711134 | -89.1454 | 179.999 | -0.2521 | -0.0079375130478072115,-4.5239360256222729e-10,-0.0079375000024701735 | 0.0079375000658951367,10.922025367768461,0.0094800055978031348
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.643Z | Extended Element | 5333599.5667104134,2184682.2787168021,360.98520971698366 | 90.8546 | 0.000287025 | 0.0962788 | -0.0093042261679496113,-8.5597749156014498,-0.0093042250905687914 | 0.009304225821110599,1.2733524303201205,0.025205147478423957
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.656Z | Extended Element | 5333598.313104474,2184682.2600173149,361.00321743374252 | -89.1454 | -0.000099024 | 179.904 | -0.0093038137888101537,-8.1316377286291352e-11,-0.007937500006429234 | 0.0093038254762999421,10.6876136177712,0.030559021340402146
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.667Z | Extended Element | 5333588.5006619329,2184682.1136500426,361.01413463701283 | -89.1454 | -0.000443383 | 179.99 | -0.0093038427737340574,1.5730592333719268e-10,-0.0079375000007323154 | 0.0093040472977474753,10.018091861851738,0.029674724000958302
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.678Z | Extended Element | 5333578.6882137982,2184681.9672826868,361.01117720080515 | -89.1454 | 0.000147015 | -179.936 | -0.0093039480799461914,3.4536275334422663e-10,-0.0079375000023673026 | 0.0093038069857242604,10.87259040001106,0.030280247757223239
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.689Z | Extended Element | 5333568.8757786192,2184681.8209155235,360.99490550357973 | -89.1454 | 0.000165022 | -179.85 | -0.0093038872142640026,-1.3027792294292781e-10,-0.0079375000004547492 | 0.0093038727442563401,10.203113802640949,0.029435698013641896
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.700Z | Extended Element | 5333548.1426691869,2184681.5116501516,360.91808346041489 | -89.1454 | 179.999 | -0.2521 | -0.0079375127672362041,5.4408232479761689e-10,-0.0079375000004114644 | 0.0079375001079626268,10.92202540023618,0.0093579056340263415
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.753Z | Extended Element | 5333597.1025364948,2184681.9497205084,360.9835459123567 | -89.1454 | 0.00159042 | -0.0962788 | -0.0093042260382144876,-1.5783994807292989e-10,-0.0093042251398974974 | 0.0093042257769351822,10.922230290153417,0.025205146758319894
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.762Z | Extended Element | 5333598.2111195894,2184681.9662571335,360.99758380529562 | -89.1454 | -0.0000193936 | 179.904 | -0.0093038187178104172,1.4012667721834813e-10,-0.0079375000021693915 | 0.0093039096864486279,10.581258541202828,0.030719312410551036
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.774Z | Extended Element | 5333588.3986768015,2184681.819889857,361.00834071767076 | -89.1454 | -0.000512221 | 179.99 | -0.0093038384874804606,-2.5641498649033113e-10,-0.0079374999998863167 | 0.0093041051447756706,9.9117366864189496,0.029812117001270913
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.786Z | Extended Element | 5333578.5862286333,2184681.6735225003,361.00524588887464 | -89.1454 | -0.00000677567 | -179.936 | -0.0093038961595749078,-3.8329484033996289e-10,-0.0079375000000568453 | 0.0093038206999143599,10.766235124127318,0.030440538304915565
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.797Z | Extended Element | 5333568.7737936554,2184681.5271553406,360.98881390081601 | -89.1454 | 0.0000609697 | -179.85 | -0.0093039597726222757,-2.2905309253225526e-10,-0.0079375000012439877 | 0.0093038725535136667,10.096758430114805,0.02957308912973259
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.808Z | Extended Element | 5333548.0406847876,2184681.2178899776,360.9118031554292 | -89.1454 | 180 | -0.2521 | -0.0079375042057691619,-2.8037799181075312e-10,-0.0079374999997726386 | 0.0079375003267553781,10.922025411809162,0.0093065939064564344
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.861Z | Extended Element | 5333597.0005517025,2184681.6559607107,360.97784871797029 | -89.1454 | 0.000232383 | -0.0962788 | -0.0093042255344656603,6.024155898108764e-10,-0.0093042254052589889 | 0.00930422640257942,10.92223041202857,0.025205146876571723
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.874Z | Extended Element | 5333598.1091347057,2184681.6724969521,360.99188661113118 | -89.1454 | -0.0000207991 | 179.904 | -0.0093038164396201488,-6.803950760416055e-10,-0.0079375000027302346 | 0.0093038353585097652,10.474903464547685,0.030879603292253369
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.884Z | Extended Element | 5333588.2966916729,2184681.5261296714,361.00248323261479 | -89.1454 | 0.000527642 | 179.99 | -0.0093039428865853164,-3.5621011029811468e-10,-0.0079375000008091254 | 0.0093038317782707727,9.8053815122554457,0.029949508570273981
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.897Z | Extended Element | 5333578.4842434684,2184681.3797623143,360.99925101123375 | -89.1454 | 0.000111288 | -179.936 | -0.009303966239161205,2.4800807587524008e-10,-0.0079375000000000036 | 0.009303811019156975,10.659879853419179,0.030600829491470687
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.909Z | Extended Element | 5333568.6718086936,2184681.2333951574,360.98265873235044 | -89.1454 | 0.0000414877 | -179.85 | -0.0093038789276467596,2.9990823715270725e-10,-0.0079375000039141694 | 0.0093039065351131142,9.9904030601221816,0.029710480404450703
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:08.921Z | Extended Element | 5333547.9387003928,2184680.9241298027,360.90545928473102 | -89.1454 | 180 | -0.2521 | -0.0079375106348599928,3.4109679248217976e-10,-0.007937500002334499 | 0.0079375000945523157,10.922025421967678,0.0092552821805829046
