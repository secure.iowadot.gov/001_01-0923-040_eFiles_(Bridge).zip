Properties of the parts of a building model (IFC4X3_ADD2), part 14 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.433Z | Extended Element | 5333570.5466349749,2184687.5745057762,361.01762758611437 | 0.854589 | 0.000022991 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.442Z | Extended Element | 5333570.6609221371,2184687.5762105407,361.01790181882876 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.454Z | Extended Element | 5333570.7752092946,2184687.5779153043,361.0181760515157 | 0.854589 | 0.0000231059 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.466Z | Extended Element | 5333570.8894964559,2184687.579620068,361.01845028421792 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.478Z | Extended Element | 5333571.0037836162,2184687.5813248325,361.01872451690735 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.488Z | Extended Element | 5333571.1180707756,2184687.5830295966,361.01899874960242 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.499Z | Extended Element | 5333571.2323579378,2184687.5847343607,361.01927298229703 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.508Z | Extended Element | 5333571.3466450972,2184687.5864391252,361.01954721500636 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.520Z | Extended Element | 5333571.4609322557,2184687.5881438889,361.01982144770926 | 0.854589 | 0.0000295189 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.530Z | Extended Element | 5333571.5752194179,2184687.5898486529,361.02009568039631 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.540Z | Extended Element | 5333571.6895065783,2184687.5915534166,361.02036991309825 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.551Z | Extended Element | 5333571.8037937405,2184687.5932581811,361.02064414578689 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.562Z | Extended Element | 5333571.9180808999,2184687.5949629452,361.02091837847479 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.571Z | Extended Element | 5333572.0323680593,2184687.5966677098,361.02119261118077 | 0.854589 | 0.0000219277 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.579Z | Extended Element | 5333572.1466552205,2184687.5983724738,361.02146684386952 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.587Z | Extended Element | 5333572.2609423799,2184687.6000772375,361.02174107656288 | 0.854589 | 0.0000296175 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.597Z | Extended Element | 5333572.3752295421,2184687.601782002,361.02201530928085 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.612Z | Extended Element | 5333572.4895168021,2184687.6034867675,361.02223511422198 | 0.854589 | 0.0000218863 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.621Z | Extended Element | 5333572.6038041944,2184687.6051915353,361.02238443491905 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.632Z | Extended Element | 5333572.7180915847,2184687.6068963027,361.0225337556181 | 0.854589 | 0.000029675 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.642Z | Extended Element | 5333572.832378977,2184687.6086010705,361.02268307631806 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.652Z | Extended Element | 5333572.9466663683,2184687.6103058378,361.02283239701177 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.663Z | Extended Element | 5333573.0609537605,2184687.6120106056,361.02298171770667 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.672Z | Extended Element | 5333573.1752411528,2184687.6137153725,361.02313103840584 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.683Z | Extended Element | 5333573.289528545,2184687.6154201408,361.02328035910244 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.692Z | Extended Element | 5333573.4038159354,2184687.6171249081,361.02342967979803 | 0.854589 | 0.0000163232 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.703Z | Extended Element | 5333573.5181033285,2184687.618829675,361.02357900050708 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.714Z | Extended Element | 5333573.6323907217,2184687.6205344433,361.02372832119693 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.724Z | Extended Element | 5333573.746678113,2184687.6222392106,361.02387764188933 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.735Z | Extended Element | 5333573.8609655043,2184687.6239439785,361.02402696260839 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.744Z | Extended Element | 5333573.9752528965,2184687.6256487463,361.02417628329232 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.752Z | Extended Element | 5333574.0895402869,2184687.6273535131,361.02432560399916 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.761Z | Extended Element | 5333574.2038276792,2184687.6290582819,361.02447492467928 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.769Z | Extended Element | 5333574.3181150705,2184687.6307630488,361.02462424539385 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.779Z | Extended Element | 5333574.4324024646,2184687.6324678161,361.02477356608881 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.788Z | Extended Element | 5333574.546689854,2184687.6341725839,361.02492288677809 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.798Z | Extended Element | 5333574.6609772462,2184687.6358773517,361.02507220747299 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.809Z | Extended Element | 5333574.7752646385,2184687.6375821191,361.02522152817858 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.819Z | Extended Element | 5333574.8895520298,2184687.6392868869,361.02537084887081 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.828Z | Extended Element | 5333575.0038394229,2184687.6409916538,361.02552016957691 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.837Z | Extended Element | 5333575.1181268143,2184687.6426964221,361.02566949028289 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.849Z | Extended Element | 5333575.2324142056,2184687.6444011894,361.02581881098291 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.858Z | Extended Element | 5333575.3467015969,2184687.6461059568,361.0259681316777 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.871Z | Extended Element | 5333575.4609889891,2184687.6478107246,361.02611745236629 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.882Z | Extended Element | 5333575.5752763795,2184687.6495154919,361.02626677305227 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.892Z | Extended Element | 5333575.6895637708,2184687.6512202593,361.02641609377321 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.902Z | Extended Element | 5333575.8038511639,2184687.6529250271,361.02656541446106 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.913Z | Extended Element | 5333575.9181385571,2184687.6546297949,361.02671473516108 | 0.854589 | 0.000022991 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.922Z | Extended Element | 5333576.0324259475,2184687.6563345618,361.02686405585047 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.934Z | Extended Element | 5333576.1467133388,2184687.6580393291,361.02701337655958 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.948Z | Extended Element | 5333576.261000731,2184687.6597440965,361.02716269725107 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.957Z | Extended Element | 5333576.3752881233,2184687.6614488652,361.02731201794364 | 0.854589 | 0.0000218702 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.968Z | Extended Element | 5333576.4895755146,2184687.663153633,361.02746133864639 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.980Z | Extended Element | 5333576.6038629068,2184687.6648583999,361.02761065934061 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.989Z | Extended Element | 5333576.7181502972,2184687.6665631672,361.02775998003602 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:38.999Z | Extended Element | 5333576.8324376903,2184687.6682679355,361.02790930074013 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.008Z | Extended Element | 5333576.9467250817,2184687.6699727029,361.02805862144777 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.020Z | Extended Element | 5333577.0610124739,2184687.6716774707,361.02820794213898 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.031Z | Extended Element | 5333577.1752998661,2184687.673382238,361.02835726283905 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.041Z | Extended Element | 5333577.2895872574,2184687.6750870054,361.02850658352241 | 0.854589 | 0.000021985 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.052Z | Extended Element | 5333577.4038746497,2184687.6767917732,361.02865590424489 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.064Z | Extended Element | 5333577.518162041,2184687.6784965396,361.02880522494064 | 0.854589 | 0.0000218288 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.074Z | Extended Element | 5333577.6324494332,2184687.6802013088,361.02895454563458 | 0.854589 | 0.0000296176 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.082Z | Extended Element | 5333577.7467368236,2184687.6819060752,361.02910386632095 | 0.854589 | 0.0000295763 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.091Z | Extended Element | 5333577.8610242158,2184687.683610843,361.02925318702552 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.100Z | Extended Element | 5333577.9753116062,2184687.6853156104,361.02940250772872 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.109Z | Extended Element | 5333578.0895990003,2184687.6870203787,361.02955182842379 | 0.854589 | 0.00001643 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.119Z | Extended Element | 5333578.2038863916,2184687.688725146,361.02970114911676 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.130Z | Extended Element | 5333578.3181737829,2184687.6904299133,361.02985046981053 | 0.854589 | 0.000016438 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.139Z | Extended Element | 5333578.4324611751,2184687.6921346807,361.02999979051964 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.151Z | Extended Element | 5333578.5467485674,2184687.6938394485,361.03014911121284 | 0.854589 | 0.0000162739 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.160Z | Extended Element | 5333578.6610359605,2184687.6955442168,361.03029843191285 | 0.854589 | 0.0000153666 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.171Z | Extended Element | 5333578.7753233528,2184687.6972489841,361.03044775260179 | 0.854589 | 0.000021985 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.181Z | Extended Element | 5333578.8896107432,2184687.6989537515,361.03059707332199 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.191Z | Extended Element | 5333579.0038981335,2184687.7006585188,361.03074639401234 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.201Z | Extended Element | 5333579.1181855258,2184687.7023632866,361.03089571470969 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.210Z | Extended Element | 5333579.232472918,2184687.704068054,361.03104503540851 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.220Z | Extended Element | 5333579.3467603102,2184687.7057728227,361.03119435610006 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.231Z | Extended Element | 5333579.4610477025,2184687.7074775891,361.03134367680872 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.239Z | Extended Element | 5333579.5753350938,2184687.7091823569,361.03149299749896 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.249Z | Extended Element | 5333579.689622486,2184687.7108871238,361.03164231820415 | 0.854589 | 0.000016438 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.258Z | Extended Element | 5333579.8039098764,2184687.7125918921,361.03179163889297 | 0.854589 | 0.0000153092 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.266Z | Extended Element | 5333579.9181972686,2184687.7142966595,361.03194095959122 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.274Z | Extended Element | 5333580.0324846609,2184687.7160014268,361.03209028029454 | 0.854589 | 0.0000153585 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.283Z | Extended Element | 5333580.1467720522,2184687.7177061946,361.03223960098671 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.300Z | Extended Element | 5333580.2610595152,2184687.7194109629,361.03229424217722 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.309Z | Extended Element | 5333580.3753470024,2184687.7211157326,361.03231864995945 | 0.854589 | 0.0000162739 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.320Z | Extended Element | 5333580.4896344896,2184687.7228205008,361.03234305774794 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.330Z | Extended Element | 5333580.6039219778,2184687.7245252705,361.03236746553938 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.339Z | Extended Element | 5333580.7182094622,2184687.7262300393,361.03239187331337 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.350Z | Extended Element | 5333580.8324969495,2184687.727934808,361.03241628110476 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.359Z | Extended Element | 5333580.9467844367,2184687.7296395767,361.03244068889757 | 0.854589 | 0.000021985 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.370Z | Extended Element | 5333581.061071923,2184687.7313443469,361.03246509666292 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.381Z | Extended Element | 5333581.1753594102,2184687.7330491156,361.0324895044505 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.389Z | Extended Element | 5333581.2896468956,2184687.7347538848,361.03251391223523 | 0.854589 | 0.0000163232 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.400Z | Extended Element | 5333581.4039343838,2184687.7364586531,361.03253832002576 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.408Z | Extended Element | 5333581.5182218691,2184687.7381634223,361.03256272779475 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.418Z | Extended Element | 5333581.6325093564,2184687.7398681915,361.03258713557966 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.427Z | Extended Element | 5333581.7467968436,2184687.7415729607,361.03261154337196 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.438Z | Extended Element | 5333581.8610843299,2184687.74327773,361.03263595114674 | 0.854589 | 0.0000153665 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.448Z | Extended Element | 5333581.9753718181,2184687.7449824982,361.03266035892437 | 0.854589 | 0.0000219277 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.458Z | Extended Element | 5333582.0896593025,2184687.7466872674,361.03268476670991 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.467Z | Extended Element | 5333582.2039467907,2184687.7483920371,361.03270917449152 | 0.854589 | 0.000022991 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.475Z | Extended Element | 5333582.318234276,2184687.7500968054,361.03273358227926 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.483Z | Extended Element | 5333582.4325217642,2184687.7518015746,361.03275799006821 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.490Z | Extended Element | 5333582.5468092505,2184687.7535063433,361.03278239786016 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.500Z | Extended Element | 5333582.6610967359,2184687.7552111121,361.03280680562307 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.509Z | Extended Element | 5333582.7753842231,2184687.7569158813,361.03283121341389 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.521Z | Extended Element | 5333582.8896717103,2184687.7586206505,361.03285562119413 | 0.854589 | 0.0000219277 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.531Z | Extended Element | 5333583.0039591985,2184687.7603254197,361.03288002898648 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.540Z | Extended Element | 5333583.1182466848,2184687.7620301885,361.03290443675075 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.551Z | Extended Element | 5333583.2325341711,2184687.7637349567,361.032928844553 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.560Z | Extended Element | 5333583.3468216546,2184687.7654397259,361.03295325233501 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.570Z | Extended Element | 5333583.4611091418,2184687.7671444956,361.03297766009825 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.580Z | Extended Element | 5333583.5753966309,2184687.7688492644,361.03300206789874 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.589Z | Extended Element | 5333583.6896841172,2184687.7705540336,361.03302647568955 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.600Z | Extended Element | 5333583.8039716035,2184687.7722588023,361.03305088345911 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.609Z | Extended Element | 5333583.9182590898,2184687.7739635706,361.03307529124601 | 0.854589 | 0.0000218863 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.619Z | Extended Element | 5333584.032546578,2184687.7756683403,361.0330996990204 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.629Z | Extended Element | 5333584.1468340652,2184687.7773731095,361.03312410681627 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.638Z | Extended Element | 5333584.2611215506,2184687.7790778782,361.03314851460124 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.646Z | Extended Element | 5333584.375409035,2184687.780782647,361.03317292237938 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.654Z | Extended Element | 5333584.4896965241,2184687.7824874162,361.03319733015564 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.661Z | Extended Element | 5333584.6039840113,2184687.7841921854,361.03322173794152 | 0.854589 | 0.0000295683 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.670Z | Extended Element | 5333584.7182714967,2184687.7858969537,361.03324614572722 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.679Z | Extended Element | 5333584.8325589858,2184687.7876017238,361.03327055350917 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.688Z | Extended Element | 5333584.9468464712,2184687.7893064921,361.03329496129038 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.697Z | Extended Element | 5333585.0611339593,2184687.7910112618,361.03331936907199 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.706Z | Extended Element | 5333585.1754214447,2184687.79271603,361.03334377686275 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.716Z | Extended Element | 5333585.2897089319,2184687.7944207992,361.03336818464874 | 0.854589 | 0.0000162739 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.725Z | Extended Element | 5333585.4039964192,2184687.796125568,361.03339259243387 | 0.854589 | 0.0000219276 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.735Z | Extended Element | 5333585.5182839064,2184687.7978303377,361.03341700020155 | 0.854589 | 0.0000230485 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.746Z | Extended Element | 5333585.6325713918,2184687.7995351059,361.03344140799231 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.755Z | Extended Element | 5333585.7468588781,2184687.8012398747,361.03346581578609 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.767Z | Extended Element | 5333585.8611463662,2184687.8029446444,361.03349022356406 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.775Z | Extended Element | 5333585.9754338516,2184687.804649414,361.03351463134339 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.783Z | Extended Element | 5333586.0897213388,2184687.8063541828,361.0335390391275 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.792Z | Extended Element | 5333586.2040088261,2184687.8080589515,361.03356344690729 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.801Z | Extended Element | 5333586.3182963114,2184687.8097637207,361.03358785469112 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.812Z | Extended Element | 5333586.4325837987,2184687.8114684895,361.03361226247154 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.822Z | Extended Element | 5333586.5468712831,2184687.8131732587,361.03363667026065 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.834Z | Extended Element | 5333586.6611587722,2184687.8148780279,361.03366107803936 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.842Z | Extended Element | 5333586.7754462585,2184687.8165827966,361.03368548582506 | 0.854589 | 0.000016438 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.853Z | Extended Element | 5333586.8897337457,2184687.8182875654,361.033709893609 | 0.854589 | 0.0000230485 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.863Z | Extended Element | 5333587.004021232,2184687.8199923346,361.03373430138879 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.872Z | Extended Element | 5333587.1183087183,2184687.8216971038,361.0337587091787 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.882Z | Extended Element | 5333587.2325962065,2184687.8234018721,361.03378311696355 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.891Z | Extended Element | 5333587.3468836928,2184687.8251066422,361.03380752473089 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.901Z | Extended Element | 5333587.4611711809,2184687.8268114105,361.03383193253615 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.910Z | Extended Element | 5333587.5754586663,2184687.8285161802,361.0338563403011 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.920Z | Extended Element | 5333587.6897461498,2184687.830220948,361.03388074808845 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.931Z | Extended Element | 5333587.8040336398,2184687.8319257176,361.03390515587495 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.947Z | Extended Element | 5333587.9183211224,2184687.8336304859,361.03391954962183 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.959Z | Extended Element | 5333588.0326085687,2184687.8353352547,361.03381904837437 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.967Z | Extended Element | 5333588.1468960121,2184687.8370400229,361.03371854713089 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.975Z | Extended Element | 5333588.2611834574,2184687.8387447922,361.0336180459006 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.983Z | Extended Element | 5333588.3754709028,2184687.84044956,361.03351754466331 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:39.991Z | Extended Element | 5333588.489758349,2184687.8421543287,361.03341704341284 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.001Z | Extended Element | 5333588.6040457925,2184687.8438590961,361.03331654217658 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.009Z | Extended Element | 5333588.7183332387,2184687.8455638643,361.03321604094663 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.019Z | Extended Element | 5333588.8326206831,2184687.8472686335,361.03311553969979 | 0.854589 | 0.0000295108 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.029Z | Extended Element | 5333588.9469081284,2184687.8489734018,361.03301503845006 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.039Z | Extended Element | 5333589.0611955719,2184687.8506781701,361.03291453720942 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.049Z | Extended Element | 5333589.1754830182,2184687.8523829374,361.03281403596316 | 0.854589 | 0.0000218863 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.058Z | Extended Element | 5333589.2897704616,2184687.8540877062,361.03271353472081 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.071Z | Extended Element | 5333589.4040579088,2184687.8557924754,361.03261303347836 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.079Z | Extended Element | 5333589.5183453541,2184687.8574972437,361.0325125322338 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.087Z | Extended Element | 5333589.6326327994,2184687.8592020124,361.03241203100487 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.096Z | Extended Element | 5333589.746920242,2184687.8609067802,361.0323115297586 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.104Z | Extended Element | 5333589.8612076892,2184687.8626115485,361.03221102851109 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.114Z | Extended Element | 5333589.9754951363,2184687.8643163163,361.03211052727653 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.124Z | Extended Element | 5333590.0897825789,2184687.866021086,361.03201002602952 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.134Z | Extended Element | 5333590.2040700233,2184687.8677258538,361.03190952479002 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.141Z | Extended Element | 5333590.3183574695,2184687.8694306221,361.03180902353984 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.150Z | Extended Element | 5333590.4326449148,2184687.8711353904,361.03170852230284 | 0.854589 | 0.0000295188 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.158Z | Extended Element | 5333590.5469323592,2184687.8728401586,361.03160802106476 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.167Z | Extended Element | 5333590.6612198055,2184687.8745449279,361.03150751980962 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.177Z | Extended Element | 5333590.7755072517,2184687.8762496961,361.03140701858177 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.190Z | Extended Element | 5333590.8897946952,2184687.8779544644,361.03130651733238 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.202Z | Extended Element | 5333591.0040821405,2184687.8796592322,361.03120601610487 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.212Z | Extended Element | 5333591.1183695849,2184687.881364,361.03110551486651 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.221Z | Extended Element | 5333591.2326570312,2184687.8830687692,361.03100501360973 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.230Z | Extended Element | 5333591.3469444755,2184687.8847735375,361.03090451237921 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.238Z | Extended Element | 5333591.4612319218,2184687.8864783063,361.0308040111247 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.249Z | Extended Element | 5333591.5755193653,2184687.8881830745,361.03070350987974 | 0.854589 | 0.0000163807 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.257Z | Extended Element | 5333591.6898068115,2184687.8898878428,361.03060300864843 | 0.854589 | 0.0000295601 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
