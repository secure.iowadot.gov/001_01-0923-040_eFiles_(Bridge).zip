Properties of the parts of a building model (IFC4X3_ADD2), part 34 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.253Z | Line | 5333602.2613895284,2184685.0328917131,360.56406256366353 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268418878316879,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.262Z | Line | 5333601.368017043,2184685.184684427,360.56207241853377 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268698275089264,3.9180740714073181e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.272Z | Line | 5333601.4070024723,2184682.571309967,360.56072080996194 | 0 | 0 | 0 | 0,0,-0.12699972827078909 | 0.00026268512010574341,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.281Z | Line | 5333600.513408714,2184682.7230993775,360.55865286839474 | 0 | 0 | 0 | 0,0,-0.12699972828636419 | 0.00026268605142831802,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.291Z | Line | 5333600.5523781404,2184680.1097246758,360.50836491498785 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.92179936170578e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.301Z | Line | 5333599.6600789903,2184680.2615362885,360.50623663381646 | 0 | 0 | 0 | 0,0,-0.12699972828630735 | 0.00026268605142831802,3.9185397326946259e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.310Z | Line | 5333599.6991654364,2184677.648160445,360.45595212968772 | 0 | 0 | 0 | 0,0,-0.12699972827084594 | 0.00026268512010574341,3.9222650229930878e-06,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.321Z | Line | 5333557.621632589,2184687.0800320441,360.61526645626219 | 0 | 0 | 0 | 0,0,0 | 0,0.0012057586573064327,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.329Z | Line | 5333557.6216325881,2184687.0812378027,360.61526645626219 | 0 | 0 | 0 | -0.00045982841402292252,0,0 | 0,0.02973914286121726,4.4747707761416677e-09
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.348Z | Extended Element | 5333557.6225546431,2184687.0710040252,360.23442820343416 | 90.8485 | -1.35969 | 89.8814 | 2.7139535063724907e-10,-1.8053469830192626e-10,5.2437075515054943e-10 | 2.0859791737593123,0.38100000000072881,0.085726458914761119
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.413Z | Extended Element | 5333580.4128660765,2184689.4427215317,360.37925017704606 | -179.146 | -0.118524 | 90 | -9.4127300398483271e-10,-5.5287718847552014e-13,-2.8661871834256836e-10 | 0.090488499214370285,0.04444999999981171,0.044450000519037955
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.428Z | Extended Element | 5333580.4126821943,2184689.4427187843,360.46814998682436 | -179.146 | -0.118524 | 90 | -2.6394286131714573e-09,-1.3981281410391233e-12,-6.0377619570672891e-11 | 0.090488498338122947,0.044449999998951661,0.04445000045179387
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.442Z | Extended Element | 5333580.4130499596,2184689.4427242754,360.29035036725946 | -179.146 | -0.118524 | 90 | -1.4667387790434638e-09,-4.2376345488204237e-12,7.3453751761598518e-10 | 0.090488501313170183,0.044449999997755063,0.044450001051143127
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.458Z | Extended Element | 5333580.4423598303,2184687.4388717711,360.51571767994193 | -179.146 | -0.118524 | 90 | -5.9451880224381526e-10,-3.3865583948244904e-12,6.2151815638511465e-10 | 0.090488498617490906,0.044449999997138473,0.044450001267898595
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.472Z | Extended Element | 5333580.4425437115,2184687.438874518,360.42681787019973 | -179.146 | -0.118524 | 90 | 2.1337224626050144e-09,2.5941089554226693e-12,6.2476699161373439e-10 | 0.090488502123036441,0.044450000002959997,0.044450001367865227
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.488Z | Extended Element | 5333580.4427275909,2184687.4388772626,360.33791806043604 | -179.146 | -0.118524 | 90 | -6.4254573189925779e-10,1.8915390087581585e-12,-1.8998420857341269e-09 | 0.090488498411975232,0.044450000002205878,0.044449999392487373
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.502Z | Extended Element | 5333579.5581306061,2184686.9811345786,360.51378013720841 | -179.146 | -0.118524 | 90 | -3.4983916458175557e-10,3.8598291229874349e-13,1.2001988049237244e-09 | 0.090488501493331486,0.044450000000691839,0.044450001516804415
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.516Z | Extended Element | 5333579.5583144855,2184686.981137326,360.42488032742847 | -179.146 | -0.118524 | 90 | 1.7189550893803585e-09,-1.4982563800725046e-12,1.6181592871200579e-10 | 0.090488499857419774,0.04444999999895935,0.044450000967264314
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.527Z | Extended Element | 5333579.5584983667,2184686.9811400706,360.33598051763141 | -179.146 | -0.118524 | 90 | -1.3625192363253547e-09,-3.1138702727417922e-12,-3.9556980260813113e-10 | 0.090488498682315482,0.044449999999038502,0.044450000215083912
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.542Z | Extended Element | 5333579.5878082421,2184684.9772875663,360.56134783032985 | -179.146 | -0.118524 | 90 | 6.9242021838444856e-10,-7.048493733119443e-13,-5.2550314100230366e-10 | 0.09048850073717235,0.044449999999821292,0.044449999985596816
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.557Z | Extended Element | 5333579.5879001813,2184684.9772889432,360.51689792548126 | 0.854042 | -179.881 | 3.88252e-19 | 5.7177559215082496e-10,-6.0907000276611001e-10,5.8501814503841842e-14 | 0.090488500512620709,0.044449999731666634,0.044450000002197371
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.572Z | Extended Element | 5333579.5881760018,2184684.9772930569,360.38354821081839 | -179.146 | -0.118524 | 90 | 1.5188587054737468e-09,5.25348514690549e-12,-2.0145931103887627e-10 | 0.090488501835711332,0.044450000007449919,0.044450000306583332
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.585Z | Extended Element | 5333578.7035251427,2184684.519549571,360.55935766086566 | -179.146 | -0.118524 | 90 | -7.5539095811816281e-11,-3.5992250846383911e-12,5.4840246926923797e-11 | 0.090488501010087069,0.044449999996896396,0.04445000033657602
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.598Z | Extended Element | 5333578.7037090249,2184684.5195523184,360.47045785108764 | -179.146 | -0.118524 | 90 | 1.8093463324819758e-09,-2.6729417290649593e-12,-2.8661872181201531e-10 | 0.090488502901727927,0.044449999999365407,0.044450000519037955
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.612Z | Extended Element | 5333578.7038929043,2184684.5195550635,360.38155804129241 | -179.146 | -0.118524 | 90 | -2.5517491938908954e-09,-5.7054361235486795e-12,1.0073887661554703e-09 | 0.090488498425779162,0.044449999994640013,0.044450001252111557
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.626Z | Extended Element | 5333578.733421186,2184682.5157058206,360.55800607662849 | -179.146 | -0.118524 | 90 | -2.5570131012564445e-09,-5.2026577490593695e-12,-2.9184852451402676e-10 | 0.09048849935722425,0.044449999996808848,0.044450000220322958
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.642Z | Extended Element | 5333578.7336050672,2184682.5157085666,360.46910626688037 | -179.146 | -0.118524 | 90 | 5.2091830154976648e-10,-4.0163358749900624e-12,3.9004723409452602e-10 | 0.090488501437970881,0.044449999996496452,0.044450001367329454
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.653Z | Extended Element | 5333578.7337889457,2184682.5157113108,360.38020645711902 | -179.146 | -0.118524 | 90 | -2.5304653511470931e-09,2.3077130484328023e-12,5.7368911010602375e-10 | 0.090488497372090818,0.044450000002812892,0.044450001081946452
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.665Z | Extended Element | 5333577.8489168147,2184682.0579645224,360.555938110721 | -179.146 | -0.118524 | 90 | 1.6812950892619583e-09,-1.8460927231345181e-14,1.6129578575552195e-10 | 0.090488501830154361,0.044450000002139181,0.044450000904387638
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.677Z | Extended Element | 5333577.849100695,2184682.0579672693,360.4670383009518 | -179.146 | -0.118524 | 90 | 1.4316053273399909e-09,-1.4441434159628841e-12,6.4742331634670691e-10 | 0.09048850252686183,0.044450000000584113,0.044450000984699228
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.690Z | Extended Element | 5333577.8492845772,2184682.0579700149,360.37813849115184 | -179.146 | -0.118524 | 90 | 4.1840885617316914e-10,2.8854453548721182e-12,6.2150335919386457e-10 | 0.090488501571111296,0.044450000003194601,0.044450001169616227
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.704Z | Extended Element | 5333577.878704912,2184680.0541191595,360.55010008654062 | 0.854042 | -179.881 | -3.88252e-19 | -6.7187040653227115e-10,1.9408832180323188e-10,-9.2738317025720107e-15 | 0.090488498611275919,0.044450000534824965,0.044450000000447465
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.717Z | Extended Element | 5333577.8789807344,2184680.0541232754,360.41675037190851 | -179.146 | -0.118524 | 90 | 6.9357157517213608e-10,5.9333787882920319e-13,5.537602668082009e-11 | 0.090488500682885553,0.044450000002618936,0.044450000336040234
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.729Z | Extended Element | 5333577.8791646156,2184680.0541260196,360.32785056214715 | -179.146 | -0.118524 | 90 | -2.9162583459196867e-10,1.3811417287623584e-12,1.2306436078524108e-10 | 0.090488499856952703,0.044450000001920467,0.044450001099917161
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.742Z | Extended Element | 5333576.9957709722,2184679.5964041809,360.41462206637118 | -179.146 | -0.118524 | 90 | 1.5458870503137767e-09,1.3420098365912736e-12,-1.0387898770336523e-09 | 0.090488500621084766,0.044450000003478693,0.044449999298277726
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.758Z | Extended Element | 5333576.9959548516,2184679.5964069245,360.32572225657174 | -179.146 | -0.118524 | 90 | 2.0383215046382297e-09,1.0574666142737499e-12,-4.1082104731970936e-10 | 0.090488502187175329,0.044450000001562025,0.044450000235559374
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.772Z | Extended Element | 5333577.025492209,2184677.5925549287,360.49768730123998 | 0.854042 | -179.881 | 0 | 1.5147415960425903e-10,-2.7157296550450738e-10,-1.1542294897637362e-12 | 0.090488500371394859,0.044450000706138623,0.044450000000965356
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.788Z | Extended Element | 5333577.0257680314,2184677.5925590447,360.36433758660957 | -179.146 | -0.118524 | 90 | 2.8084710251841116e-09,4.3759509904539584e-12,-5.4127532664316469e-10 | 0.09048850372552944,0.044450000006505848,0.044450000904387617
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.801Z | Extended Element | 5333577.0259519126,2184677.5925617879,360.27543777684809 | -179.146 | -0.118524 | 90 | 5.5654605229937815e-10,1.382970127306038e-12,3.345891931572087e-10 | 0.09048850232856985,0.044450000001741215,0.04445000108708453
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.812Z | Extended Element | 5333580.3007725924,2184689.7985583888,360.41073345283024 | -89.1454 | -0.00000157981 | 90 | -2.9749558372316187e-10,-1.927624726505428e-14,-2.4151326598331746e-09 | 0.24923849968305906,0.04445000000007384,0.044449999562404266
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.825Z | Extended Element | 5333580.4882120863,2184689.8013543338,360.34762110370019 | -89.1454 | -0.00000157981 | 90 | 2.7670149504999131e-10,-9.0382562545343603e-14,-6.1441738849477012e-10 | 0.24923850049196061,0.044449999999960146,0.044450000433752454
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.841Z | Extended Element | 5333580.4880807446,2184689.8013523752,360.4111209678702 | -89.1454 | -0.00000157979 | 90 | -8.6416812594691805e-10,-8.5372681146722584e-14,-1.134494630183891e-09 | 0.24923849935058418,0.04445000000006058,0.044450000275278637
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.855Z | Extended Element | 5333580.2960206671,2184687.1236373498,360.4583011575433 | 90.8546 | 0.00000158685 | 90 | 7.9695830490500441e-10,-2.4868995751603507e-14,-1.5820294553547942e-09 | 0.24923650087127952,0.044450000000008316,0.044449999826488312
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.869Z | Extended Element | 5333580.4833288211,2184687.1264313338,360.45868867253597 | 90.8546 | 0.00000158685 | 90 | 8.0497133958523648e-10,-2.4868995751603507e-14,-9.7075576743765879e-10 | 0.24923650134767331,0.044450000000008316,0.044449999855166358
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.882Z | Extended Element | 5333580.4834601618,2184687.126433298,360.39518880838961 | 90.8546 | 0.00000158685 | 90 | -7.1679195912111027e-10,-8.8262730457699945e-15,-4.8699783095074167e-10 | 0.24923649912333881,0.04445000000007851,0.044450000921519933
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.896Z | Extended Element | 5333576.99558709,2184679.596401433,360.50352187614482 | -179.146 | -0.118524 | 90 | -3.0126454109158374e-10,-2.3492180423190234e-12,1.4670753466228259e-09 | 0.090488498806819487,0.044449999998147499,0.044450002077729089
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.911Z | Extended Element | 5333555.9989378061,2184684.1808766546,360.53435686035931 | -179.146 | -0.118524 | 90 | 1.3266450923921091e-09,5.3620163864565029e-12,2.6562101129723459e-10 | 0.090488501300324972,0.044450000007502488,0.044450000947728101
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.926Z | Extended Element | 5333555.9991216892,2184684.1808794029,360.4454570505826 | -179.146 | -0.118524 | 90 | 6.7214388915770584e-10,-2.662717268897552e-12,-2.8661871140367445e-10 | 0.090488501764619922,0.044449999997622697,0.04445000005065719
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.941Z | Extended Element | 5333555.9993055677,2184684.180882147,360.35655724079044 | -179.146 | -0.118524 | 90 | -4.6819393501040807e-10,-2.4661106490242446e-12,6.242376025811236e-10 | 0.090488498743832413,0.044449999999711047,0.04445000150480842
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.955Z | Extended Element | 5333556.0288338484,2184682.1770329052,360.53300527611913 | -179.146 | -0.118524 | 90 | 1.8797761056066342e-09,-3.4226094181022404e-14,1.1081842700433331e-09 | 0.090488502857239125,0.044450000000316243,0.044450001717772844
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.970Z | Extended Element | 5333556.0290177278,2184682.1770356516,360.44410546637818 | -179.146 | -0.118524 | 90 | -7.9964770915985639e-11,4.1665976224791734e-13,6.4252299314393468e-10 | 0.090488499960779664,0.044450000002469819,0.044450001385835922
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.984Z | Extended Element | 5333556.0292016109,2184682.1770383944,360.35520565661704 | -179.146 | -0.118524 | 90 | 1.6804548030879829e-10,-6.1917658500387773e-12,8.0296994053874471e-10 | 0.090488501003384555,0.044449999997697248,0.044450001545424056
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:44.997Z | Extended Element | 5333555.144329478,2184681.7192916069,360.53093731022335 | -179.146 | -0.118524 | 90 | -2.6977241551762177e-09,-4.5948869709100393e-12,1.5857631874283129e-10 | 0.090488498387825189,0.044449999997582271,0.044450000804956757
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.012Z | Extended Element | 5333555.1445133593,2184681.7192943543,360.44203750044932 | -179.146 | -0.118524 | 90 | -1.0599834898705751e-10,-3.6114097823336522e-12,6.2694785821215682e-10 | 0.090488500838648692,0.044449999998391554,0.04445000096400907
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.028Z | Extended Element | 5333555.1446972406,2184681.7192970994,360.3531376906501 | -179.146 | -0.118524 | 90 | -1.2996229231676537e-09,-3.3279767830407536e-12,-5.4129013424275563e-10 | 0.090488500789771165,0.044449999998672829,0.044450000006822726
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.041Z | Extended Element | 5333555.1742095174,2184679.7154476135,360.48064938114737 | -179.146 | -0.118524 | 90 | 1.2229482010406301e-10,5.4946394656418818e-12,8.8062192954430074e-11 | 0.090488500342208483,0.044450000005971178,0.044450000428798833
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.056Z | Extended Element | 5333555.1743933978,2184679.71545036,360.3917495714058 | -179.146 | -0.118524 | 90 | 4.8492405924083215e-10,3.7136578534546771e-12,8.7094496198369953e-10 | 0.09048850146249432,0.044450000004071691,0.04445000138311643
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.070Z | Extended Element | 5333555.1745772781,2184679.7154531032,360.30284976164182 | -179.146 | -0.118524 | 90 | -1.6974179423145941e-09,-1.7007610597641332e-12,3.2227212565238972e-10 | 0.090488498628511216,0.044449999998614667,0.044450000830321176
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.084Z | Extended Element | 5333554.2909997534,2184679.2577285175,360.47852107564444 | -179.146 | -0.118524 | 90 | -1.8438797641517901e-09,-1.7392753903777702e-12,5.2103732092745325e-10 | 0.090488499237685566,0.044450000000305093,0.044450001166352573
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.098Z | Extended Element | 5333554.2911836365,2184679.2577312635,360.38962126586927 | -179.146 | -0.118524 | 90 | 5.4738643479046445e-10,7.1500791398726449e-13,6.5755951725310346e-10 | 0.090488501700125318,0.044450000001087425,0.044450001401087139
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.114Z | Extended Element | 5333554.2913675169,2184679.2577340091,360.3007214560721 | -179.146 | -0.118524 | 90 | -2.4081031613221171e-10,4.1610742629316633e-12,-1.9950452054273704e-10 | 0.09048850066557565,0.044450000004555013,0.044450000481537445
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.130Z | Extended Element | 5333554.3209048733,2184677.2538820133,360.47268650073607 | 0.854042 | -179.881 | -3.88252e-19 | -6.3986903969803777e-10,-3.0928342872882375e-10,-1.6053616769262646e-12 | 0.090488499300852621,0.044450000237757858,0.044449999998860325
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.144Z | Extended Element | 5333554.3211806966,2184677.2538861302,360.3393367861064 | -179.146 | -0.118524 | 90 | 1.2748941902174238e-09,5.1916110299643492e-13,-2.7376306430126895e-10 | 0.090488502148380973,0.044450000002573431,0.044450000703954939
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.159Z | Extended Element | 5333554.3213645751,2184677.2538888729,360.25043697634487 | -179.146 | -0.118524 | 90 | 4.7913283063305556e-10,-3.7487374315858801e-14,6.9806035257746757e-10 | 0.090488501318438094,0.044450000003962958,0.044450001217430465
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.174Z | Extended Element | 5333603.1172435507,2184689.7813913105,360.47411254807866 | -179.146 | -0.118524 | 90 | -8.8058914327060478e-11,-9.2158572440048658e-13,-3.0655557953229717e-10 | 0.090488500993511745,0.044449999999427101,0.044450000436542639
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.190Z | Extended Element | 5333603.117427432,2184689.781394057,360.38521273829781 | -179.146 | -0.118524 | 90 | 4.4186300451887206e-11,-4.418763965841066e-12,-2.8932896009581377e-10 | 0.090488500089027368,0.044449999999544215,0.044450000321324762
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.204Z | Extended Element | 5333603.1176113123,2184689.781396802,360.29631292850144 | -179.146 | -0.118524 | 90 | -2.0490851446175462e-09,-3.2473641831121114e-12,-1.9732082634504877e-10 | 0.090488497924617939,0.044449999998897496,0.044450000718976659
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.219Z | Extended Element | 5333603.1469211867,2184687.7775442963,360.52168024119425 | -179.146 | -0.118524 | 90 | -8.3748077917000785e-12,-1.107197666883053e-12,1.5638625810998619e-10 | 0.090488502009858529,0.044450000000898868,0.044450001367865213
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.234Z | Extended Element | 5333603.1471050698,2184687.7775470451,360.43278043145727 | -179.146 | -0.118524 | 90 | 1.4049508709201852e-09,2.7190472096094709e-12,4.2379011758186813e-10 | 0.090488501385229583,0.044450000004909243,0.044450000898948711
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.247Z | Extended Element | 5333603.1472889492,2184687.7775497888,360.34388062168847 | -179.146 | -0.118524 | 90 | 5.0146581331844686e-11,-8.8845597545628152e-14,-8.0772883173652055e-10 | 0.09048850114451433,0.044450000001925088,0.044449999700749587
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.261Z | Extended Element | 5333602.2626919635,2184687.3198071066,360.51974269846056 | -179.146 | -0.118524 | 90 | -7.7724775227050458e-10,2.2052359938129484e-12,6.4523322795828619e-10 | 0.090488500306168979,0.044450000004312679,0.044450000982515551
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.276Z | Extended Element | 5333602.2628758447,2184687.319809854,360.43084288868869 | -179.146 | -0.118524 | 90 | -9.3268762157983076e-10,-5.3735557670187006e-12,1.2997831283501071e-10 | 0.090488500011959419,0.044449999996629408,0.044450000266876871
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.291Z | Extended Element | 5333602.2630597251,2184687.3198125968,360.34194307889197 | -179.146 | -0.118524 | 90 | -1.8512489458055725e-09,-4.8192387580581197e-12,6.0701100049187495e-10 | 0.090488499991910901,0.044449999997239462,0.04445000128805298
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.306Z | Extended Element | 5333602.2923695985,2184685.3159600925,360.56731039157995 | -179.146 | -0.118523 | 90 | 1.2174243418927588e-09,-1.0364521740857668e-12,3.9057661271879596e-10 | 0.090488502143405342,0.044450000000972975,0.044450000801701514
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.322Z | Extended Element | 5333602.2925534779,2184685.3159628399,360.47841058183576 | -179.146 | -0.118524 | 90 | 6.0769741322408422e-10,6.4179946079878647e-12,-8.7920179817069233e-10 | 0.090488500756563006,0.044450000006959256,0.04444999976717863
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.336Z | Extended Element | 5333602.2927373592,2184685.3159655835,360.38951077207594 | -179.146 | -0.118524 | 90 | 9.6939334337520222e-10,6.2164232095263117e-12,-7.5112634861929095e-11 | 0.090488502232030296,0.044450000008253734,0.044450001110494144
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.351Z | Extended Element | 5333601.4080864992,2184684.8582220976,360.5653202221124 | -179.146 | -0.118524 | 90 | -1.1543697525651098e-09,-1.5338945391629721e-12,-3.2431157065415661e-10 | 0.090488499752016144,0.044449999998860054,0.044450000418571958
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.365Z | Extended Element | 5333601.4082703814,2184684.8582248446,360.47642041234343 | -179.146 | -0.118524 | 90 | -1.6440019484642576e-10,-1.7710173605411939e-12,-3.9572685406330521e-11 | 0.090488499772353556,0.044449999998592477,0.044450000938145315
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.380Z | Extended Element | 5333601.4084542617,2184684.8582275882,360.38752060254399 | -179.146 | -0.118524 | 90 | 3.8553671366514664e-10,-1.7038835620208914e-12,1.5378042242386591e-09 | 0.090488498485688171,0.04444999999879521,0.044450002219911314
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.394Z | Extended Element | 5333601.4379825415,2184682.8543783464,360.56396863787302 | -179.146 | -0.118523 | 90 | -1.3453191477497128e-09,-2.1372695280241771e-12,4.0780323909417326e-10 | 0.090488498699486108,0.044449999999983586,0.044450000784266579
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.410Z | Extended Element | 5333601.4381664228,2184682.8543810928,360.47506882813514 | -179.146 | -0.118524 | 90 | 5.6621629607178647e-10,3.6596767283292309e-13,-7.5084664180602445e-11 | 0.090488501492291762,0.044450000002391549,0.044450000570230616
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.425Z | Extended Element | 5333601.438350304,2184682.854383837,360.38616901837156 | -179.146 | -0.118524 | 90 | 1.2746165026222833e-09,-5.9159274701237052e-13,4.0830462968988179e-10 | 0.090488501265845372,0.044450000003297185,0.044450000914434233
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.440Z | Extended Element | 5333600.5534781693,2184682.3966370495,360.56190067197491 | -179.146 | -0.118524 | 90 | -7.3934164346312059e-11,-1.1031037194797477e-12,6.4199361105021779e-10 | 0.090488499034139053,0.044449999999402495,0.04445000125264733
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.453Z | Extended Element | 5333600.5536620514,2184682.396639796,360.47300086220298 | -179.146 | -0.118524 | 90 | 2.506691833270569e-09,2.1929368043682729e-12,-5.4129012730386172e-10 | 0.090488503380255353,0.044450000002565354,0.04445000000682274
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.465Z | Extended Element | 5333600.5538459346,2184682.3966425397,360.38410105240951 | -179.146 | -0.118524 | 90 | 7.4889562606816895e-10,-1.6293667803868317e-12,3.5506464782231184e-10 | 0.090488503716744495,0.044450000002213635,0.044450001071833278
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.479Z | Extended Element | 5333600.5833582105,2184680.3927930547,360.51161274290337 | -179.146 | -0.118523 | 90 | -1.4882273330352191e-09,-5.2796551852640761e-12,5.177820672219724e-10 | 0.090488499597317751,0.044449999995166217,0.04445000079951783
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.490Z | Extended Element | 5333600.5835420908,2184680.3927958026,360.42271293316259 | -179.146 | -0.118524 | 90 | 2.1468510025268728e-09,-2.6952988452233484e-12,-8.7594654793465843e-10 | 0.090488502136147134,0.044449999999294505,0.044449999404717638
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.503Z | Extended Element | 5333600.5837259684,2184680.3927985458,360.33381312339668 | -179.146 | -0.118524 | 90 | -7.1475390883701806e-10,-1.1410872247097359e-12,-1.164049030777381e-09 | 0.090488499183734472,0.044450000000881944,0.044449999354255948
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.523Z | Extended Element | 5333599.7001484474,2184679.9350739601,360.5094844374043 | -179.146 | -0.118524 | 90 | -5.9350575148942042e-10,-1.3279516375419576e-12,6.2476699508318134e-10 | 0.090488500488041801,0.044450000000675491,0.044450001836245964
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.536Z | Extended Element | 5333599.7003323305,2184679.9350767066,360.42058462762583 | -179.146 | -0.118524 | 90 | 1.7669981866585971e-09,-5.8637122934968033e-14,4.2608860537085569e-10 | 0.090488501703787888,0.044450000001990279,0.044450001403806588
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.548Z | Extended Element | 5333599.7005162118,2184679.9350794517,360.33168481783076 | -179.146 | -0.118524 | 90 | 3.5930355912761058e-11,1.8451108696471152e-12,-4.9009752853268473e-10 | 0.090488501879090202,0.044450000002252313,0.044449999950191207
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.562Z | Extended Element | 5333599.7301455075,2184677.9312288254,360.45919995760624 | -179.146 | -0.118524 | 90 | -4.3619709927389394e-10,-3.8609115904364444e-12,5.2656559668129432e-11 | 0.090488500645267339,0.044449999996433467,0.044450000697971837
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.577Z | Extended Element | 5333599.7303293897,2184677.9312315709,360.37030014786774 | -179.146 | -0.118524 | 90 | 7.9412726394778588e-12,-2.9231686515807098e-12,1.3014237500164061e-09 | 0.090488500914345987,0.044449999999123413,0.044450002044307255
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.591Z | Extended Element | 5333599.7305132682,2184677.931234315,360.28140033809871 | -179.146 | -0.118524 | 90 | 6.9404409996920435e-10,2.0528405364483859e-12,1.0530835578559383e-10 | 0.090488500596677124,0.04445000000426004,0.044450000613565716
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.606Z | Extended Element | 5333550.793675378,2184676.4169540307,359.48574838136619 | -68.6848 | 90 | -20.46 | -2.6110499133618301e-27,1.252598698302536e-09,3.4183222918926504e-10 | 1.4668500000192533,0.20320000274273761,0.10160000034183225
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.619Z | Extended Element | 5333550.7921587881,2184676.5185588431,360.70942204085765 | -89.1448 | -7.33712e-07 | 90 | -9.1064125919134854e-10,-2.181082865993481e-19,-1.0869102015989562e-10 | 0.10163225320087567,0.032366292544250351,0.03185000064381055
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.628Z | Line | 5333550.7921591876,2184676.5185427186,360.71269704021586 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.640Z | Extended Element | 5333550.9968531514,2184676.4199705687,360.70942234461961 | 90.8552 | -0.000374488 | 90 | -7.992679058472096e-10,-2.1827945868855812e-19,1.126275112669356e-09 | 0.10163225257567542,0.032366291788928539,0.031850001878778206
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.655Z | Extended Element | 5333557.4984780038,2184676.5169662,359.51459008699948 | -68.6848 | 90 | -20.46 | -1.1368683772161863e-13,-2.272554280030092e-10,-1.1623108031599827e-10 | 1.4668500000191396,0.20320000126288348,0.10159999988376894
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.667Z | Extended Element | 5333557.4969614139,2184676.6185710132,360.73826374649087 | -89.1448 | -7.33712e-07 | 90 | -7.5080156983256323e-10,1.1368661961466102e-13,-1.1503195657298904e-09 | 0.10163225376286046,0.032366292561181703,0.031849999602182009
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.677Z | Line | 5333557.4969618144,2184676.6185548878,360.74153874584908 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.688Z | Extended Element | 5333557.7016557781,2184676.519982737,360.73826405025295 | 90.8552 | -0.000374488 | 90 | -7.7474283724661724e-11,-1.1368705599957075e-13,-3.8660999705439347e-10 | 0.10163225405444803,0.03236629256256527,0.03185000036589309
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.698Z | Extended Element | 5333569.0795007218,2184676.6897144928,359.55112411343634 | -68.6848 | 90 | -20.46 | 0,-9.1114824129311152e-10,-1.0660659854888621e-10 | 1.4668500000192528,0.20320000057899065,0.10159999989339337
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.709Z | Extended Element | 5333569.0779841319,2184676.791319306,360.77479777292785 | -89.1448 | -7.33712e-07 | 90 | -1.2821610298332872e-09,-5.684363696767683e-14,-1.2333668929914721e-09 | 0.10163225282935588,0.032366292335543785,0.031849999519134684
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.719Z | Line | 5333569.0779845314,2184676.7913031811,360.77807277228607 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.730Z | Extended Element | 5333569.2826784961,2184676.6927310308,360.77479807668982 | 90.8552 | -0.000374488 | 90 | -5.3454701478108926e-10,-1.1368705591398472e-13,-4.6092742036346612e-11 | 0.10163225321888575,0.032366292337144081,0.031850000706410343
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.743Z | Extended Element | 5333583.4033972444,2184676.9033768578,359.57009414352109 | -68.6848 | 90 | -20.46 | 1.1368683772161603e-13,-3.4913160930395166e-10,-1.0160917940371661e-10 | 1.466850000019448,0.20320000114102452,0.10159999989839077
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.755Z | Extended Element | 5333583.4018806536,2184677.0049816701,360.79376780301254 | -89.1448 | -7.33712e-07 | 90 | -1.0594256040143453e-09,-5.6843636968342629e-14,7.3278605362478433e-10 | 0.10163225305209318,0.032366292719577569,0.031850001485287618
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.764Z | Line | 5333583.401881054,2184677.0049655456,360.79704280237075 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6773250283440575e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.777Z | Extended Element | 5333583.6065750169,2184676.9063933948,360.79376810677451 | 90.8552 | -0.000374488 | 90 | 2.7347964425644698e-10,-1.1368705591415708e-13,-1.2305094347977996e-09 | 0.10163225402691241,0.032366291964152666,0.031849999521993654
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.790Z | Extended Element | 5333594.9844199624,2184677.0761251519,359.56423515845876 | -68.6848 | 90 | -20.46 | 0,-7.5707343597860828e-11,-1.0315265308591393e-10 | 1.4668500000193343,0.2032000014144488,0.1015999998968473
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.804Z | Extended Element | 5333594.9829033716,2184677.1777299647,360.78790881795015 | -89.1448 | -7.33712e-07 | 90 | -5.4239158667608573e-10,-2.1810753461695324e-19,1.3922229168128464e-09 | 0.10163225359278279,0.032366292959978935,0.031850002144724485
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.812Z | Line | 5333594.982903773,2184677.1777138398,360.79118381730837 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.826Z | Extended Element | 5333595.1875977367,2184677.079141689,360.78790912171218 | 90.8552 | -0.000374488 | 90 | -9.2589751957635376e-10,-2.1819312066156321e-19,2.3476588251539199e-10 | 0.1016322532060247,0.032366292204657088,0.031850000987268971
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.839Z | Extended Element | 5333601.6892225891,2184677.1761373221,359.55218086854717 | -68.6848 | 90 | -20.46 | -5.6843418860808015e-14,1.2569776656134818e-09,3.5933309106006561e-10 | 1.4668500000192775,0.20320000274713379,0.10160000035933305
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.851Z | Extended Element | 5333601.6877059983,2184677.2777421349,360.77585452803868 | -89.1448 | -7.33712e-07 | 90 | -2.2506732915694842e-09,5.6843200753858218e-14,-1.5148280589974417e-09 | 0.10163225188450108,0.032366292761642983,0.031849999237673503
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.861Z | Line | 5333601.6877063988,2184677.27772601,360.77912952739689 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.873Z | Extended Element | 5333601.8924003616,2184677.1791538601,360.7758548318007 | 90.8552 | -0.000374488 | 90 | -7.8149881734691725e-11,-2.1819312066156321e-19,-3.3945613550981357e-10 | 0.10163225329679337,0.032366292763197066,0.031850000413046954
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.887Z | Extended Element | 5333555.4743935037,2184689.8994926978,359.50712449368905 | -68.6848 | 90 | -20.46 | -5.2220998267236602e-27,1.1777335067429966e-09,3.4746044930145104e-10 | 1.4668500000192977,0.20320000266787719,0.10160000034746351
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.899Z | Extended Element | 5333555.4728769138,2184690.001097511,360.7307981531805 | -89.1448 | -7.33712e-07 | 90 | -1.6500383070858633e-09,-2.1810678263456286e-19,-9.5746889366629673e-10 | 0.10163225246148075,0.032366292628801314,0.031849999795032682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.910Z | Line | 5333555.4728773143,2184690.0010813856,360.73407315253877 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.923Z | Extended Element | 5333555.6775712781,2184689.9025092353,360.73079845694252 | 90.8552 | -0.000374488 | 90 | 7.5495651103831641e-10,-2.1810695500752085e-19,5.0118799431800309e-10 | 0.10163225488687466,0.03236629263045622,0.031850001253691099
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.936Z | Extended Element | 5333562.1791961314,2184689.9995048675,359.53596619932233 | -68.6848 | 90 | -20.46 | -5.684341886081324e-14,-2.9484466212359004e-10,-5.7626414751155153e-10 | 1.4668500000192408,0.20320000119529902,0.10159999942373892
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.952Z | Extended Element | 5333562.1776795406,2184690.1011096807,360.75963985881373 | -89.1448 | -7.33712e-07 | 90 | -1.4901986176735687e-09,-5.6843636968342629e-14,-1.1826239510251413e-10 | 0.10163225302346549,0.032366292645562102,0.031850000634239171
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.962Z | Line | 5333562.1776799401,2184690.1010935553,360.762914858172 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.975Z | Extended Element | 5333562.3823739039,2184690.002521405,360.75964016257575 | 90.8552 | -0.000374488 | 90 | 6.6240164461733539e-10,5.6843200754025381e-14,8.3639611903052469e-10 | 0.10163225403734077,0.032366291890351728,0.031850001588899224
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:45.989Z | Extended Element | 5333573.7602188485,2184690.1722531607,359.57250022575926 | -68.6848 | 90 | -20.46 | -5.2220998267236602e-27,-3.6500964902612393e-11,-1.0097843394785144e-10 | 1.4668500000192977,0.20320000145364273,0.10159999989902463
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.002Z | Extended Element | 5333573.7587022576,2184690.2738579735,360.79617388525077 | -89.1448 | -7.33712e-07 | 90 | -6.4822980505134889e-10,5.6843200753939193e-14,-1.9039578637650156e-10 | 0.10163225348694484,0.032366292420208435,0.031850000562105789
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.011Z | Line | 5333573.7587026581,2184690.2738418486,360.79944888460898 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.025Z | Extended Element | 5333573.9633966219,2184690.1752696983,360.79617418901279 | 90.8552 | -0.000374488 | 90 | -5.5165005771511613e-10,-2.1810678263519553e-19,-7.0392167008520579e-10 | 0.10163225320177856,0.03236629166487371,0.031850000048581434
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.037Z | Extended Element | 5333588.0841153702,2184690.3859155248,359.59147025584394 | -68.6848 | 90 | -20.46 | 5.6843418860802796e-14,-3.5851327345261561e-10,3.6968035577178426e-10 | 1.4668500000194364,0.20320000113164766,0.10160000036968334
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.049Z | Extended Element | 5333588.0825987794,2184690.4875203376,360.81514391533534 | -89.1448 | -7.33712e-07 | 90 | -1.3568169537986033e-09,1.1368661961332944e-13,8.4807256529872976e-10 | 0.10163225277835958,0.032366292804299056,0.031850001600574128
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.059Z | Line | 5333588.0825991798,2184690.4875042127,360.81841891469367 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6773250283440575e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.073Z | Extended Element | 5333588.2872931436,2184690.3889320632,360.81514421909742 | 90.8552 | -0.000374488 | 90 | -2.9645648629847797e-10,5.6843200753939193e-14,9.1654329655369016e-10 | 0.10163225307848268,0.032366292048871925,0.031850001669046404
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.087Z | Extended Element | 5333599.6651380891,2184690.558663819,359.58561127078161 | -68.6848 | 90 | -20.46 | -5.2220998267236602e-27,-8.5089007746524779e-11,-9.752440521815231e-11 | 1.4668500000193796,0.20320000140507191,0.10159999990247857
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.098Z | Extended Element | 5333599.6636214992,2184690.6602686332,360.80928493027301 | -89.1448 | -7.33712e-07 | 90 | -1.9515958219473756e-09,-2.1810979056414471e-19,-3.6604965716544036e-10 | 0.10163225331904918,0.032366292287550905,0.031850000386451902
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.111Z | Line | 5333599.6636218987,2184690.6602525068,360.81255992963128 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.124Z | Extended Element | 5333599.8683158625,2184690.561680357,360.80928523403503 | 90.8552 | -0.000374488 | 90 | -4.0252202324536825e-07,-2.181069563602237e-19,5.118975070217413e-10 | 0.10164029839495935,0.032366695342335286,0.031850399815505671
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.137Z | Extended Element | 5333606.369940714,2184690.6586759896,359.57355698087008 | -68.6848 | 90 | -20.46 | -5.2220998267236602e-27,1.2548719590789946e-09,3.6496132505003942e-10 | 1.4668500000193796,0.20320000274503289,0.1016000003649643
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.152Z | Extended Element | 5333606.3684241241,2184690.7602808024,360.79723064036153 | -89.1448 | -7.33712e-07 | 90 | -1.1037696005351173e-09,5.6843200753273401e-14,-4.7549493118956287e-10 | 0.10163225300775132,0.032366292846193939,0.031850000277006629
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.160Z | Line | 5333606.3684245246,2184690.760264677,360.8005056397198 | 0 | 0 | 0 | 0,-0.10158868366852403,-2.6716406864579767e-11 | 0.001516345888376236,0,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:46.174Z | Extended Element | 5333606.5731184892,2184690.6616925276,360.79723094412356 | 90.8552 | -0.000374488 | 90 | -1.4922367852964783e-09,-2.1810695500497101e-19,8.6899806404569513e-10 | 0.10163225188270239,0.032366292090766795,0.031850001621501173
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:50.820Z | Extended Element | 5333548.8196536051,2184690.2828575601,359.06903013216868 | 0.854681 | -0.41599 | 90 | -0.0025200063595982591,-1.8296566266062797e-05,-0.011141944120703774 | 2.150079890338938,1.9458580645130805,0.49372098996985914
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:50.907Z | Extended Element | 5333544.1460244963,2184676.3177953549,359.04755412774773 | 0.854589 | -0.419234 | 90 | -0.0025201397284173588,-1.8440251366769189e-05,-0.01114194432551785 | 2.150187673702987,1.9459782196870725,0.49374291242098517
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:50.979Z | Complex Chain | 5333551.6447228892,2184690.2249992215,361.88963747993432 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.13333514844998717,-0.85407500000050263 | 0.001990162767469883,1.0576427650343945e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:50.990Z | Complex Chain | 5333551.4161478598,2184690.2215896831,361.8896374798594 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000919967 | 0.0019901628293044499,1.0576427650343945e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:50.997Z | Complex Chain | 5333551.1875728304,2184690.2181801433,361.8896374800234 | 0 | 0 | 0 | 0,-0.13333514798432589,-0.85407499995309522 | 0.0019901636987924576,2.4546291388372055e-09,8.7197804532479495e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.006Z | Complex Chain | 5333550.9589978028,2184690.2147706049,361.88963748048224 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.13333514798432589,-0.854075000005448 | 0.001990162767469883,1.0576427650343945e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.013Z | Complex Chain | 5333550.7304227734,2184690.211361066,361.889637479942 | 0 | 0 | 0 | -6.1847635519918231e-11,-0.13333514844998717,-0.85407500000431114 | 0.001990162767469883,1.5233038025419532e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.023Z | Complex Chain | 5333550.5018477431,2184690.2079515271,361.88963748046427 | 0 | 0 | 0 | -6.1847618823204775e-11,-0.13333514938130975,-0.85407499998811076 | 0.0019901618979949274,1.0576425013564261e-09,1.4551915228366852e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.030Z | Complex Chain | 5333550.2732727146,2184690.2045419891,361.88963747980398 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.13333514844998717,-0.85407500001380399 | 0.0019901618979818753,5.9198147772665521e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.040Z | Complex Chain | 5333550.0446976861,2184690.2011324503,361.88963748037952 | 0 | 0 | 0 | -6.1847635519918231e-11,-0.13333514844998717,-0.85407500000601644 | 0.001990162767469883,1.5233038025419532e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.048Z | Complex Chain | 5333549.8161226576,2184690.1977229118,361.88963748061536 | 0 | 0 | 0 | 0,-0.13333514844998717,-0.85407500000857439 | 0.0019901628293175185,1.0576425152342139e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.058Z | Complex Chain | 5333549.6637393031,2184690.1954498859,361.88963748011406 | 0 | 0 | 0 | -6.1860683025702357e-11,-0.13333514844998717,-0.85407500000055947 | 0.0019901636987924576,1.9889648955606631e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.066Z | Complex Chain | 5333549.5113559496,2184690.19317686,361.88963747986406 | 0 | 0 | 0 | -9.9315714181293091e-10,-0.13333514844998717,-0.85407500000249215 | 0.0019901618361473083,1.988965339649873e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.077Z | Complex Chain | 5333549.3589725941,2184690.1909038341,361.88963748021041 | 0 | 0 | 0 | 0,-0.13333514938130975,-0.85407500000516379 | 0.0019901628293175185,1.0576425152342139e-09,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.086Z | Complex Chain | 5333548.9319580635,2184690.1861219504,361.82552317329248 | 0 | 0 | 0 | -2.3746115870078993e-09,-0.13650979427620769,-0.38576368331236593 | 0.0020375568419694901,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.097Z | Complex Chain | 5333549.0208483525,2184690.1874478813,361.84095724037792 | 0 | 0 | 0 | 0,-0.13650979445897191,-0.39846363803544116 | 0.0020375589895100512,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.106Z | Complex Chain | 5333549.1351358667,2184690.189152651,361.86080104030253 | 0 | 0 | 0 | 0,-0.13650979493505822,-0.41116359562666471 | 0.0020375578620233509,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.115Z | Complex Chain | 5333549.2494233828,2184690.1908574197,361.88064484081571 | 0 | 0 | 0 | -1.482508987966924e-09,-0.13650979427620769,-0.42386249999721692 | 0.0020375475287437439,0,1.4495071809506044e-11
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.126Z | Complex Chain | 5333551.6441487242,2184690.2710632025,360.85553221131687 | 0 | 0 | 0 | -1.1858093359237015e-09,-0.36191163025542633,-0.05526269414684748 | 0.0054018970431942044,5.6818490884458228e-10,0.095250076324538441
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.134Z | Complex Chain | 5333551.6495494731,2184689.9091515532,360.53510210438316 | 0 | 0 | 0 | -0.0054018990602134973,0,-0.055262695563897068 | 9.3132257461547852e-10,0.36191163258142844,0.09525007482546391
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.144Z | Complex Chain | 5333551.6256749751,2184690.2247150932,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515344241167,0 | 0.0019901652086009142,0,1.3012192100662165
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.152Z | Complex Chain | 5333551.3970999457,2184690.2213055543,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515297675039,0 | 0.0019901661399234888,0,1.301219210048254
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.162Z | Complex Chain | 5333551.1685249172,2184690.2178960154,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515064844909,0 | 0.0019901670708928143,0,1.3012192101280053
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.171Z | Complex Chain | 5333550.9399498878,2184690.214486477,360.14102468649969 | 0 | 0 | 0 | -5.0353835467573105e-10,-0.13333515344241167,0 | 0.0019901642772783544,0,1.3012192100600777
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.182Z | Complex Chain | 5333550.7113748575,2184690.2110769381,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515111411037,0 | 0.0019901661395702137,0,1.3012192101327233
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.192Z | Complex Chain | 5333550.482799829,2184690.2076673997,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515344241165,0 | 0.0019901661399235031,0,1.3012192100571216
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.201Z | Complex Chain | 5333550.2542247977,2184690.2042578608,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515251108902,0 | 0.0019901652086009277,0,1.3012192100537678
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.211Z | Complex Chain | 5333550.0256497683,2184690.2008483219,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515251108902,0 | 0.0019901661399235023,0,1.30121921005445
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.219Z | Complex Chain | 5333549.7970747398,2184690.1974387835,360.14102468649969 | 0 | 0 | 0 | 0,-0.1333351529767503,0 | 0.0019901661399235023,0,1.3012192100583722
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.229Z | Complex Chain | 5333549.6446913853,2184690.1951657576,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515251108899,0 | 0.0019901661399235018,0,1.3012192100575195
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.237Z | Complex Chain | 5333549.4923080299,2184690.1928927316,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515297675028,0 | 0.0019901652086009272,0,1.3012192100638291
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.244Z | Complex Chain | 5333549.3399246754,2184690.1906197062,360.14102468649969 | 0 | 0 | 0 | 0,-0.13333515344241154,0 | 0.0019901652086009268,0,1.3012192100665008
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.252Z | Line | 5333548.9112281213,2184690.1921625193,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.261Z | Line | 5333549.1942257769,2184690.1963838525,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.270Z | Line | 5333549.7602210892,2184690.2048265198,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.280Z | Line | 5333550.0432187449,2184690.2090478535,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.290Z | Line | 5333550.3262164006,2184690.2132691867,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.298Z | Line | 5333550.6092140563,2184690.2174905203,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.309Z | Line | 5333550.8922117129,2184690.221711854,360.92842626134592 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.317Z | Line | 5333548.9161529979,2184689.8619995536,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.327Z | Line | 5333549.1991506536,2184689.8662208868,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.336Z | Line | 5333549.4821483102,2184689.8704422205,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.347Z | Line | 5333549.7651459659,2184689.8746635541,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.356Z | Line | 5333550.0481436215,2184689.8788848878,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.366Z | Line | 5333550.3311412772,2184689.883106221,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.377Z | Line | 5333550.6141389338,2184689.8873275546,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.385Z | Line | 5333550.8971365895,2184689.8915488883,360.9284262611107 | 0 | 0 | 0 | 0,0,-1.828803657607466 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.395Z | Line | 5333548.885570446,2184690.2092442736,360.90302621039001 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.405Z | Line | 5333548.885570446,2184690.2092442731,360.58259610279543 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.415Z | Line | 5333548.885570446,2184690.2092442727,360.2621659952008 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.426Z | Line | 5333548.885570446,2184690.2092442717,359.94173588760617 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.435Z | Line | 5333548.885617801,2184690.2060696194,359.73853548120536 | 0 | 0 | 0 | 0,0,0 | 2.0317780403420329,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.445Z | Line | 5333548.885570446,2184690.2092442713,359.63693527800496 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.455Z | Line | 5333548.885570446,2184690.2092442736,359.15042270527675 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.463Z | Line | 5333548.885570446,2184690.2092442708,359.39367899162448 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.473Z | Line | 5333548.8904953208,2184689.8790813074,359.15042270527675 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.482Z | Line | 5333548.8904953208,2184689.8790813047,359.39367899162448 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.493Z | Line | 5333548.8904953208,2184689.8790813051,359.63693527800496 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.501Z | Line | 5333548.8904953208,2184689.8790813056,359.94173588760617 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.513Z | Line | 5333548.8904953208,2184689.8790813065,360.2621659952008 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.522Z | Line | 5333548.8904953208,2184689.879081307,360.58259610279543 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.530Z | Line | 5333548.8904953208,2184689.8790813074,360.90302621039001 | 0 | 0 | 0 | 0,0,0 | 2.0317780412733555,0.030307012144476175,1.8940227164421231e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.542Z | Line | 5333549.9522539154,2184690.2251554551,360.91890124232935 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.550Z | Line | 5333549.9522539154,2184690.2251554551,360.59847113457812 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.562Z | Line | 5333549.9522539154,2184690.2251554551,360.27804102721598 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.570Z | Line | 5333549.9522539154,2184690.2251554551,359.95761091960293 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.579Z | Line | 5333549.9522539154,2184690.2251554551,359.6528103100394 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.592Z | Line | 5333549.9522539154,2184690.2251554551,359.40955402343474 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.600Z | Line | 5333549.9522539154,2184690.2251554551,359.16629773737566 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.608Z | Line | 5333549.9569401378,2184689.910991725,360.9189012423372 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.616Z | Line | 5333549.9569401378,2184689.910991725,360.59847113478367 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.626Z | Line | 5333549.9571787901,2184689.8949924884,360.27804102686525 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6342482922482304e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.633Z | Line | 5333549.9571787901,2184689.8949924884,359.95761091957593 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.643Z | Line | 5333549.9571787901,2184689.8949924884,359.65281031001865 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:51.651Z | Line | 5333549.9571787901,2184689.8949924884,359.40955402363227 | 0 | 0 | 0 | 0,0,0 | 1.7524085585027933,0.026139797642827034,1.6336798580596223e-10
