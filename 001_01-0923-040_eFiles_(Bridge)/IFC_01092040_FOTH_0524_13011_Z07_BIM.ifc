Properties of the parts of a building model (IFC4X3_ADD2), part 25 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.693Z | Line | 5333546.3310682513,2184677.619713461,360.59890838523177 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.702Z | Line | 5333546.4502966944,2184677.9631441254,360.60574066930053 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.714Z | Line | 5333546.4560238253,2184677.9796407949,360.60606885797455 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.726Z | Line | 5333546.9300156273,2184679.3449468454,360.63323055147822 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.735Z | Line | 5333546.9357427573,2184679.3614435145,360.63355873978509 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524985317 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.745Z | Line | 5333546.5702264281,2184678.3085948057,360.61261313998858 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.753Z | Line | 5333546.575953559,2184678.3250914747,360.61294132866266 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.764Z | Line | 5333546.6901561618,2184678.6540454854,360.61948561054373 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.774Z | Line | 5333546.6958832918,2184678.6705421549,360.61981379921781 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.784Z | Line | 5333546.8100858936,2184678.9994961657,360.62635808084656 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.795Z | Line | 5333546.8158130245,2184679.0159928352,360.62668626952058 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.804Z | Line | 5333547.0549712041,2184679.7048741775,360.64039102324421 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.814Z | Line | 5333547.0606983351,2184679.7213708465,360.64071921202236 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.825Z | Line | 5333547.179926781,2184680.0648015109,360.6475514952856 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524416882 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.833Z | Line | 5333547.1856539119,2184680.0812981804,360.6478796836571 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061929524416882 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.843Z | Line | 5333547.3048823578,2184680.4247288425,360.65471196775621 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.853Z | Line | 5333547.3106094887,2184680.4412255115,360.65504015575391 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.863Z | Line | 5333547.7846012851,2184681.8065315546,360.68220184930573 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061932791776599 | 0.359926613047719,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.874Z | Line | 5333547.7903284151,2184681.8230282241,360.68253003755422 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061932791776599 | 0.359926613047719,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.882Z | Line | 5333547.4248120915,2184680.7701795199,360.66158443794984 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.893Z | Line | 5333547.4305392224,2184680.7866761894,360.66191262594754 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061929524416882 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.902Z | Line | 5333547.5447418233,2184681.1156301978,360.66845690820332 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524416882 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.913Z | Line | 5333547.5504689543,2184681.1321268673,360.66878509620102 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061929524416882 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.921Z | Line | 5333547.6646715552,2184681.4610808757,360.67532937866298 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.933Z | Line | 5333547.6703986861,2184681.4775775452,360.67565756666068 | 0 | 0 | 0 | 0,-0.12495532631874084,-0.0026061929524416882 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.944Z | Line | 5333547.909556862,2184682.1664588866,360.68936232154732 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061932791776599 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.953Z | Line | 5333547.915283991,2184682.1829555565,360.68969050989466 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061932791776599 | 0.359926613047719,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.962Z | Line | 5333548.0345124388,2184682.5263862191,360.69652279347616 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061932791776599 | 0.359926613047719,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.971Z | Line | 5333548.0402395697,2184682.5428828881,360.69685098176615 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061932791776599 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.981Z | Line | 5333548.1594680147,2184682.8863135511,360.70368326572685 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061932791776599 | 0.359926613047719,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:12.992Z | Line | 5333548.1651951456,2184682.9028102201,360.70401145375712 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061932791776599 | 0.359926613047719,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.000Z | Line | 5333548.6391869457,2184684.2681162665,360.68704283350485 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.012Z | Line | 5333548.6449140776,2184684.284612936,360.68675566842575 | 0 | 0 | 0 | 0,-0.12495579943060875,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.020Z | Line | 5333548.5192572139,2184683.9226655876,360.69305624487868 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644634097815,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.032Z | Line | 5333548.5249843448,2184683.9391622567,360.69276907979958 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.042Z | Line | 5333548.3993274812,2184683.5772149083,360.69906965653871 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.051Z | Line | 5333548.405054613,2184683.5937115778,360.69878249145961 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644634097815,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.063Z | Line | 5333548.2793977475,2184683.2317642299,360.7050830682104 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.071Z | Line | 5333548.2851248793,2184683.2482608994,360.70479590313124 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.081Z | Line | 5333548.7641425235,2184684.6280435985,360.6807774204122 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.091Z | Line | 5333548.7698696535,2184684.6445402685,360.68049025526267 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644634097815,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.100Z | Line | 5333548.8890980985,2184684.9879709319,360.67451200724275 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.110Z | Line | 5333548.8948252294,2184685.004467601,360.67422484268798 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.120Z | Line | 5333549.0140536753,2184685.3478982635,360.66824659396428 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.130Z | Line | 5333549.0197808063,2184685.364394933,360.66795942931367 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.141Z | Line | 5333549.4937726045,2184686.7297009784,360.64419294765969 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620512843132,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.149Z | Line | 5333549.4994997354,2184686.7461976479,360.64390578290386 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.160Z | Line | 5333549.1339834072,2184685.6933489423,360.66223318239827 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.168Z | Line | 5333549.1397105381,2184685.7098456118,360.66194601774765 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.179Z | Line | 5333549.2539131399,2184686.0387996212,360.6562197712056 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.191Z | Line | 5333549.2596402708,2184686.0552962902,360.65593260655498 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273406791253
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.200Z | Line | 5333549.3738428736,2184686.3842502991,360.65020635939203 | 0 | 0 | 0 | 0,-0.12495579896494746,0 | 0.35992644727230072,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.211Z | Line | 5333549.3795700045,2184686.4007469686,360.64991919474141 | 0 | 0 | 0 | 0,-0.12495579943060875,0 | 0.35992644634097815,0,0.0022804273407359688
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.221Z | Line | 5333549.6187281813,2184687.0896283109,360.63792753463127 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.0022805849677638435
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.230Z | Line | 5333549.6244553123,2184687.1061249799,360.6376403697862 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.241Z | Line | 5333549.7436837582,2184687.4495556434,360.6316621213594 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.249Z | Line | 5333549.7494108891,2184687.4660523129,360.631374956233 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.259Z | Line | 5333549.8686393341,2184687.8094829754,360.62539670845456 | 0 | 0 | 0 | 0,-0.12495518615469337,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.269Z | Line | 5333549.8743664641,2184687.8259796449,360.62510954409407 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620512843132,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.279Z | Line | 5333550.3483582642,2184689.1912856898,360.6013430616901 | 0 | 0 | 0 | 0,-0.12495532678440213,0 | 0.35992661211639643,0,0.0022804180958360121
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.288Z | Line | 5333550.3540853951,2184689.2077823589,360.60105589735593 | 0 | 0 | 0 | 0,-0.12495532678440213,0 | 0.359926613047719,0,0.0022804180958928555
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.298Z | Line | 5333549.9885690669,2184688.1549336542,360.6193832971822 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620512843132,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.308Z | Line | 5333549.9942961978,2184688.1714303233,360.61909613282171 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.317Z | Line | 5333550.1084988005,2184688.5003843326,360.61336988497493 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.328Z | Line | 5333550.1142259315,2184688.5168810021,360.61308272061439 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.0022805849677638435
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.337Z | Line | 5333550.2284285324,2184688.8458350115,360.60735647348224 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.347Z | Line | 5333550.2341556633,2184688.862331681,360.60706930912175 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.357Z | Line | 5333550.5451632971,2184689.7581712385,360.59147503611604 | 0 | 0 | 0 | 0,-0.12495532678440213,0 | 0.35992661211639643,0,0.0022804180958928555
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.366Z | Line | 5333550.5508904271,2184689.774667908,360.59118787148151 | 0 | 0 | 0 | 0,-0.12495532725006342,0 | 0.359926613047719,0,0.0022804180958928555
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.376Z | Line | 5333546.0754299648,2184676.8833621289,360.58425925326878 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.388Z | Line | 5333546.0811570957,2184676.8998587984,360.58458744143149 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661118507385,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.398Z | Line | 5333545.9796306891,2184676.6074178414,360.57876955842994 | 0 | 0 | 0 | 0,-0.12495532725006342,-0.0026061945800961439 | 0.35992661211639643,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.408Z | Line | 5333545.9853578201,2184676.6239145105,360.57909774681707 | 0 | 0 | 0 | 0,-0.12495532678440213,-0.0026061945800393005 | 0.35992661211639643,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.416Z | Complex Chain | 5333550.6006520959,2184689.7389072538,360.29496350754692 | 0 | 0 | 0 | -3.7857252055406576e-10,0,0 | 1.1349385129287839,0.016929306089878082,0.2968630937261878
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.428Z | Complex Chain | 5333550.6063792249,2184689.7554039224,360.59153943650301 | 0 | 0 | 0 | 0,0,-0.60166586886452655 | 0.60159677919000387,0.0089737172238528728,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.437Z | Complex Chain | 5333550.4038470639,2184689.1720217038,360.30483153362354 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.3722634888254106,0 | 1.0722835101187229,4.6566128730773926e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.446Z | Complex Chain | 5333550.409574192,2184689.1885183752,360.60140746252216 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629758 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.456Z | Complex Chain | 5333550.2896444695,2184688.843067721,360.60742087355811 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.463Z | Complex Chain | 5333550.2839173414,2184688.8265710492,360.31084494465955 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.472Z | Complex Chain | 5333550.1697147368,2184688.4976170426,360.61343428480274 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524527847767,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.481Z | Complex Chain | 5333550.1639876086,2184688.4811203708,360.31685835590417 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.492Z | Complex Chain | 5333550.049785004,2184688.1521663647,360.61944769616048 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.500Z | Complex Chain | 5333550.0440578759,2184688.1356696934,360.32287176726186 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.512Z | Complex Chain | 5333549.9298552712,2184687.8067156854,360.62546110797462 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.522Z | Complex Chain | 5333549.9241281431,2184687.7902190136,360.32888517907605 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.533Z | Complex Chain | 5333549.8048996953,2184687.4467883534,360.63172652098621 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524527847767,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.544Z | Complex Chain | 5333549.7991725672,2184687.4302916816,360.33515059208764 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.553Z | Complex Chain | 5333549.6799441185,2184687.0868610214,360.63799193403776 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.563Z | Complex Chain | 5333549.5549885016,2184686.7269336763,360.64425737418776 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.572Z | Complex Chain | 5333549.5492613735,2184686.7104370045,360.3476814452892 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.582Z | Complex Chain | 5333549.4350587754,2184686.3814829136,360.65027076109783 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.592Z | Complex Chain | 5333549.4293316472,2184686.3649862418,360.35369483219927 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.610Z | Complex Chain | 5333549.3151290426,2184686.0360322348,360.65628417373574 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.619Z | Complex Chain | 5333549.3094019154,2184686.019535563,360.35970824483718 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.630Z | Complex Chain | 5333549.1951993108,2184685.6905815559,360.6622975846542 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.639Z | Complex Chain | 5333549.1894721827,2184685.6740848846,360.36572165575564 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.647Z | Complex Chain | 5333549.075269578,2184685.3451308776,360.66831099598971 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.654Z | Complex Chain | 5333549.0695424499,2184685.3286342057,360.37173506709115 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.662Z | Complex Chain | 5333548.9503140012,2184684.9852035455,360.67457640923232 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888635454 | 0.56838524527847767,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.672Z | Complex Chain | 5333548.9445868731,2184684.9687068737,360.3780004803337 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.682Z | Complex Chain | 5333548.8253584243,2184684.6252762121,360.68084182221071 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.690Z | Complex Chain | 5333548.7004028484,2184684.2653488801,360.68710723462289 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.698Z | Complex Chain | 5333548.6946757203,2184684.2488522083,360.39053130572432 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.707Z | Complex Chain | 5333548.5804731166,2184683.9198982012,360.69312064695328 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.716Z | Complex Chain | 5333548.5747459885,2184683.9034015294,360.39654471805471 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.728Z | Complex Chain | 5333548.460543382,2184683.574447521,360.69913405816806 | 0 | 0 | 0 | 0,-0.19732568087056279,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.739Z | Complex Chain | 5333548.4548162548,2184683.5579508496,360.40255812926949 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.750Z | Complex Chain | 5333548.340613652,2184683.2289968431,360.70514746961237 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524527847767,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.759Z | Complex Chain | 5333548.3348865239,2184683.2125001717,360.40857154071381 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.768Z | Complex Chain | 5333548.2206839444,2184682.8835462369,360.70360966442621 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.777Z | Complex Chain | 5333548.2149568163,2184682.8670495651,360.40703373552765 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.788Z | Complex Chain | 5333548.0957283666,2184682.5236189049,360.69644919328971 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.798Z | Complex Chain | 5333548.0900012394,2184682.5071222335,360.39987326439115 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.810Z | Complex Chain | 5333547.9707727898,2184682.1636915724,360.68928872084223 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.818Z | Complex Chain | 5333547.8458172139,2184681.8037642408,360.6821282495585 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524527847767,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.828Z | Complex Chain | 5333547.8400900858,2184681.787267569,360.38555232065994 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.836Z | Complex Chain | 5333547.7258874821,2184681.4583135624,360.67525577900233 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.847Z | Complex Chain | 5333547.7201603539,2184681.4418168911,360.37867985010377 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.855Z | Complex Chain | 5333547.6059577493,2184681.1128628841,360.66838330852892 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.866Z | Complex Chain | 5333547.6002306212,2184681.0963662122,360.37180737963035 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.874Z | Complex Chain | 5333547.4860280175,2184680.7674122071,360.66151083800975 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.884Z | Complex Chain | 5333547.4803008903,2184680.7509155353,360.36493490911118 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.894Z | Complex Chain | 5333547.3660982847,2184680.4219615278,360.65463836708881 | 0 | 0 | 0 | 0,-0.19732568087056279,-0.60166586888629769 | 0.56838524527847767,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.902Z | Complex Chain | 5333547.3603711566,2184680.4054648564,360.35806243819025 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.913Z | Complex Chain | 5333547.2411427088,2184680.0620341972,360.64747789512251 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.922Z | Complex Chain | 5333547.2354155807,2184680.0455375253,360.35090196622394 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.934Z | Complex Chain | 5333547.116187132,2184679.7021068647,360.64031742358662 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888635454 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.943Z | Complex Chain | 5333546.9912315561,2184679.3421795308,360.63315695042593 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524527847767,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.951Z | Complex Chain | 5333546.9855044279,2184679.3256828594,360.33658102152737 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.961Z | Complex Chain | 5333546.8713018233,2184678.9967288519,360.62628448098667 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.971Z | Complex Chain | 5333546.8655746952,2184678.9802321801,360.32970855208811 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.37226348835974932,0 | 1.0722835091874003,6.7750227823737408e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.978Z | Complex Chain | 5333546.7513720887,2184678.6512781722,360.61941201026542 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.986Z | Complex Chain | 5333546.7456449606,2184678.6347815003,360.3228360813668 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:13.998Z | Complex Chain | 5333546.6314423559,2184678.305827491,360.61253954016655 | 0 | 0 | 0 | 0,-0.19732568087056279,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.007Z | Complex Chain | 5333546.6257152278,2184678.2893308196,360.31596361126793 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,4.6566128730773926e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.017Z | Complex Chain | 5333546.5115126241,2184677.9603768117,360.6056670696787 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524527847767,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.027Z | Complex Chain | 5333546.505785496,2184677.9438801403,360.30909114078014 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372624464
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.037Z | Complex Chain | 5333546.3865570473,2184677.6004494773,360.59850659606764 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,4.6566128730773926e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.048Z | Complex Chain | 5333546.3808299191,2184677.5839528055,360.30193066716902 | 0 | 0 | 0 | -9.3132257461547852e-10,-0.37226348835974932,0 | 1.0722835101187229,6.7750227823737408e-10,0.29686309372630149
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.056Z | Complex Chain | 5333546.2616014713,2184677.2405221467,360.59134612436486 | 0 | 0 | 0 | 0,-0.19732568087056279,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.064Z | Complex Chain | 5333546.1366458936,2184676.8805948137,360.58418565371221 | 0 | 0 | 0 | 0,-0.19732568133622408,-0.60166586888629769 | 0.56838524620980024,6.949295379594933e-10,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.074Z | Complex Chain | 5333546.1309187664,2184676.8640981424,360.28760972481365 | 0 | 0 | 0 | -1.3080906843820905e-09,-0.3722634888254106,0 | 1.0722835091874003,4.6566128730773926e-10,0.29686309372630149
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.083Z | Line | 5333550.7082848772,2184689.0663303626,358.67173548140192 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.094Z | Line | 5333550.5883551454,2184688.7208796851,358.67173548155324 | 0 | 0 | 0 | 0,-0.29989278502762318,-5.6843418860808015e-14 | 0.86382387112826109,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.104Z | Line | 5333550.4684254127,2184688.3754290054,358.67173548111441 | 0 | 0 | 0 | 0,-0.2998927840963006,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.114Z | Line | 5333550.3484956799,2184688.0299783275,358.67173548125311 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.123Z | Line | 5333550.2285659481,2184687.6845276491,358.67173548117933 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386833429337,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.133Z | Line | 5333549.8536992176,2184686.6047456521,358.6717354808107 | 0 | 0 | 0 | 0,-0.29989278502762318,0 | 0.86382387112826109,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.144Z | Line | 5333549.7337694848,2184686.2592949723,358.67173548109025 | 0 | 0 | 0 | 0,-0.29989278502762318,-5.6843418860808015e-14 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.153Z | Line | 5333549.613839753,2184685.9138442948,358.67173548134514 | 0 | 0 | 0 | 0,-0.29989278549328446,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.163Z | Line | 5333549.4939100184,2184685.5683936146,358.67173548172633 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386833429337,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.171Z | Line | 5333549.3739802875,2184685.2229429358,358.67173548147747 | 0 | 0 | 0 | 0,-0.29989278316497803,0 | 0.86382386926561594,0,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.182Z | Line | 5333548.9991135588,2184684.1431609411,358.67173548153835 | 0 | 0 | 0 | 0,-0.29989278502762318,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.193Z | Line | 5333548.879183826,2184683.7977102613,358.67173548124299 | 0 | 0 | 0 | 0,-0.2998927840963006,0 | 0.86382386926561594,0,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.204Z | Line | 5333548.7592540924,2184683.4522595825,358.67173548108485 | 0 | 0 | 0 | 0,-0.2998927840963006,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.214Z | Line | 5333548.6393243605,2184683.106808905,358.67173548157547 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.225Z | Line | 5333548.5193946268,2184682.7613582239,358.67173548121332 | 0 | 0 | 0 | 0,-0.2998927840963006,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.234Z | Line | 5333548.1445278982,2184681.6815762278,358.67173548115096 | 0 | 0 | 0 | 0,-0.29989278363063931,-5.6843418860808015e-14 | 0.86382386740297079,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.245Z | Line | 5333548.0245981663,2184681.3361255499,358.67173548105228 | 0 | 0 | 0 | 0,-0.29989278363063931,-5.6843418860808015e-14 | 0.86382386740297079,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.253Z | Line | 5333547.9046684327,2184680.990674871,358.67173548180591 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.264Z | Line | 5333547.7847387018,2184680.6452241954,358.67173548140619 | 0 | 0 | 0 | 0,-0.29989278456196189,-5.6843418860808015e-14 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.273Z | Line | 5333547.664808969,2184680.2997735161,358.6717354815674 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386833429337,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.283Z | Line | 5333547.2899422385,2184679.2199915191,358.67173548115426 | 0 | 0 | 0 | 0,-0.29989278502762318,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.294Z | Line | 5333547.1700125057,2184678.8745408379,358.67173548150532 | 0 | 0 | 0 | 0,-0.29989278502762318,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.303Z | Line | 5333547.050082773,2184678.5290901591,358.67173548109878 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.313Z | Line | 5333546.9301530393,2184678.1836394779,358.6717354812144 | 0 | 0 | 0 | 0,-0.29989278502762318,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.323Z | Line | 5333546.8102233056,2184677.8381887949,358.67173548168381 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386926561594,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.520Z | Line String | 5333550.3848744268,2184683.1172165265,359.7369482336058 | 0 | 0 | 0 | -1.8349570110440254,-1.6619801996275783,0 | 0,0,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.531Z | Line String | 5333550.3848753991,2184683.1172165405,359.73853548116 | 0 | 0 | 0 | -1.834957011975348,-1.6619801996275783,0 | 0,0,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.543Z | Smart Solid | 5333548.6338699097,2184683.0910976725,359.73853548116006 | -89.1454 | 0 | 0 | -6.7056134112268202,-3.6743585951626301e-10,-1.0668 | 0,3.4137278389673549,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.554Z | Smart Solid | 5333549.6068458259,2184683.1056110649,359.73853548116006 | -89.1454 | 0 | 0 | 0,-3.4137278393166044,-1.0668 | 6.7056134112268211,1.8189894035458565e-11,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.567Z | Smart Solid | 5333551.9400069937,2184690.3294267193,359.73853548116006 | -89.1454 | 0 | 0 | -1.5777218104420236e-30,-0.97308415475179877,-1.0668 | 0.48260000000000858,4.0017900104771797e-10,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.581Z | Smart Solid | 5333547.2664867574,2184676.3643417303,359.73853548116006 | -89.1454 | 0 | 0 | 0,-0.97308415509013479,-1.0668 | 0.48260000000000236,6.184563972055912e-11,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.591Z | Smart Solid | 5333550.9742289772,2184689.8323670076,360.76637459723821 | -89.1454 | 0 | 0 | 3.944304526105059e-31,-2.8460954158999527,-0.87934823469646939 | 6.7056134112268211,-4.0381570309833137e-10,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.601Z | Smart Solid | 5333548.6338699097,2184683.0910976725,360.76637459723821 | -89.1454 | 0 | 0 | 0,-2.8460954158635738,-0.89611226822453638 | 6.7056134112268211,-3.6743591502741424e-10,-1.1102230246251565e-16
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.612Z | Smart Solid | 5333551.4571037572,2184690.0809036084,360.36101459134949 | 0 | 0 | 0 | -0.49007366014732034,-0.24853564994403249,-0.62247904495809636 | 0.49010015674609558,0.24852406106446776,0.62249399813655326
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.623Z | Smart Solid | 5333547.9501706939,2184679.727729612,360.41832249460032 | 0 | 0 | 0 | -1.6566610047801626,-3.3779014375431742,-0.67978701344023529 | 1.656675437025519,3.3778815239803004,0.67979651824372556
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.635Z | Smart Solid | 5333546.7835835312,2184676.1158177578,360.35028114846813 | 0 | 0 | 0 | -0.49007366108408185,-0.24853565228506197,-0.61174566731574131 | 0.49010013741570702,0.24852395745326603,0.61174977657234941
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.645Z | Line | 5333551.0553104626,2184689.8335764604,358.67173548115994 | 0 | 0 | 0 | -4.6807181369513273,-13.482538670301437,0 | 0,0,6.7700511863222346e-11
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.654Z | Line | 5333550.8280897876,2184686.9234411288,360.58560048731908 | 0 | 0 | 0 | 0,0,0 | 0.76639420446008444,2.2075543045066297,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.666Z | Smart Solid | 5333550.2905516913,2184686.4689742136,360.4184444148367 | 0 | 0 | 0 | -1.6566827048880992,-3.3778765712096765,-0.67990893367669059 | 1.656653316879374,3.3779062211581996,0.6799186618288463
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.676Z | Line | 5333550.9322194345,2184687.2233805722,359.93154917921652 | 0 | 0 | 0 | 0,0,0 | 0.55813491158187389,1.6076754173263907,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.685Z | Line | 5333550.8280897876,2184686.9234411283,360.2585748332678 | 0 | 0 | 0 | 0,0,0 | 0.76639420446008444,2.2075543045066297,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.696Z | Line | 5333549.9735041289,2184684.4618564155,360.6306505114419 | 0 | 0 | 0 | 0,0,0 | 0.76639420446008444,2.2075543045066297,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.704Z | Line | 5333549.9735041289,2184684.461856415,360.30362485739062 | 0 | 0 | 0 | 0,0,0 | 0.76639420446008444,2.2075543045066297,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.715Z | Line | 5333550.0776337758,2184684.7617958589,359.97659920333933 | 0 | 0 | 0 | 0,0,0 | 0.55813491158187389,1.6076754173263907,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.723Z | Line | 5333549.1189184906,2184682.0002716845,360.66626423891506 | 0 | 0 | 0 | 0,0,0 | 0.76639420352876186,2.2075543045066297,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.732Z | Line | 5333549.1189184906,2184682.000271684,360.33923858486378 | 0 | 0 | 0 | 0,0,0 | 0.76639420352876186,2.2075543045066297,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.743Z | Line | 5333549.2230481366,2184682.3002111283,360.01221293081244 | 0 | 0 | 0 | 0,0,0 | 0.55813491251319647,1.6076754173263907,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.751Z | Line | 5333548.2643327555,2184679.5386870424,360.62146138746061 | 0 | 0 | 0 | 0,0,0 | 0.76639420352876186,2.2075543045066297,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.763Z | Line | 5333548.2643327555,2184679.538687042,360.29443573340933 | 0 | 0 | 0 | 0,0,0 | 0.76639420352876186,2.2075543045066297,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.771Z | Line | 5333548.3684624014,2184679.8386264858,359.96741007935805 | 0 | 0 | 0 | 0,0,0 | 0.55813491251319647,1.607675417792052,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.783Z | Line | 5333547.4097470194,2184677.0771024013,360.56856879148876 | 0 | 0 | 0 | 0,0,0 | 0.76639420352876186,2.207554304972291,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.792Z | Line | 5333547.4097470194,2184677.0771024008,360.24154313743747 | 0 | 0 | 0 | 0,0,0 | 0.76639420352876186,2.207554304972291,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.801Z | Line | 5333547.5138766654,2184677.3770418451,359.91451748338619 | 0 | 0 | 0 | 0,0,0 | 0.55813491251319647,1.6076754173263907,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.811Z | Complex Chain | 5333551.3803126812,2184688.5614082916,360.09296096374766 | 0 | 0 | 0 | 0,0,-0.29526003586696686 | 0.48280232772231102,1.3928455510176718,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.821Z | Complex Chain | 5333550.5257270224,2184686.0998235801,360.13800111177244 | 0 | 0 | 0 | 0,0,-0.2952600358669315 | 0.48280232772231102,1.3928455510176718,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.831Z | Complex Chain | 5333549.6711413618,2184683.6382388677,360.18304073928147 | 0 | 0 | 0 | 0,0,-0.2952600358669315 | 0.48280232865363359,1.3928455505520105,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.842Z | Complex Chain | 5333548.8165556993,2184681.1766541558,360.17913460234115 | 0 | 0 | 0 | 0,0,-0.29526003586696686 | 0.48280232865363359,1.3928455510176718,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.850Z | Complex Chain | 5333547.9619700415,2184678.7150694449,360.12628320513613 | 0 | 0 | 0 | 0,0,-0.2952600358669315 | 0.48280232865363359,1.3928455510176718,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.860Z | Complex Chain | 5333547.1073843818,2184676.2534847301,360.07343015831003 | 0 | 0 | 0 | 0,0,-0.29526003586696686 | 0.48280232865363359,1.3928455510176718,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.868Z | Line | 5333551.4928342048,2184688.7704329332,358.76698567178192 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.879Z | Line | 5333551.3729044739,2184688.4249822558,358.76698567150595 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.887Z | Line | 5333551.2529747402,2184688.079531576,358.76698567190385 | 0 | 0 | 0 | 0,0,0 | 9.3132257461547852e-10,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.898Z | Line | 5333551.1330450075,2184687.7340808981,358.76698567158718 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,0 | 9.3132257461547852e-10,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.909Z | Line | 5333551.0131152757,2184687.3886302193,358.76698567110236 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.918Z | Line | 5333550.638248547,2184686.3088482213,358.81143576102409 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.929Z | Line | 5333550.5183188152,2184685.9633975415,358.81143576030644 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.937Z | Line | 5333550.3983890815,2184685.6179468646,358.8114357609586 | 0 | 0 | 0 | 0,0,0 | 9.3132257461547852e-10,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.948Z | Line | 5333550.2784593469,2184685.2724961843,358.8114357613419 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.958Z | Line | 5333550.158529616,2184684.9270455074,358.81143576099896 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 9.3132257461547852e-10,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.968Z | Line | 5333549.7836628845,2184683.8472635117,358.8558858495424 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.978Z | Line | 5333549.6637331527,2184683.5018128324,358.85588584923067 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.987Z | Line | 5333549.5438034208,2184683.1563621531,358.85588584926012 | 0 | 0 | 0 | -9.3132257461547852e-10,0,0 | 0,4.6566128730773926e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:14.998Z | Line | 5333549.423873689,2184682.8109114761,358.85588584921999 | 0 | 0 | 0 | -9.3132257461547852e-10,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.009Z | Line | 5333549.3039439553,2184682.4654607945,358.8558858493347 | 0 | 0 | 0 | -9.3132257461547852e-10,0,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.019Z | Line | 5333548.9290772257,2184681.3856787989,358.85271084339433 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.029Z | Line | 5333548.809147493,2184681.0402281205,358.85271084347471 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.038Z | Line | 5333548.6892177584,2184680.6947774421,358.8527108439211 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.049Z | Line | 5333548.5692880275,2184680.3493267666,358.85271084364058 | 0 | 0 | 0 | 0,-9.3132257461547852e-10,0 | 9.3132257461547852e-10,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.057Z | Line | 5333548.074491567,2184678.9240940902,358.80032323850571 | 0 | 0 | 0 | 0,0,0 | 0,9.3132257461547852e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.069Z | Line | 5333547.9545618324,2184678.5786434095,358.80032323904021 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 9.3132257461547852e-10,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.081Z | Line | 5333547.8346320996,2184678.2331927302,358.80032323868397 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.089Z | Line | 5333547.7147023669,2184677.8877420495,358.80032323890117 | 0 | 0 | 0 | -9.3132257461547852e-10,-9.3132257461547852e-10,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.098Z | Line | 5333547.5947726332,2184677.542291366,358.80032323844659 | 0 | 0 | 0 | -9.3132257461547852e-10,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.106Z | Line | 5333547.2031355994,2184676.4142034715,358.74793563323544 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.115Z | Line | 5333550.7729812702,2184689.0203434867,358.76698567154773 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.123Z | Line | 5333550.6530515375,2184688.6748928092,358.76698567154682 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.134Z | Line | 5333550.5331218038,2184688.3294421295,358.76698567146985 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672086251
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.143Z | Line | 5333550.4131920729,2184687.9839914525,358.7669856716376 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.154Z | Line | 5333550.2932623401,2184687.6385407737,358.76698567097907 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.165Z | Line | 5333549.9183956068,2184686.5587587762,358.81143576130722 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.176Z | Line | 5333549.7984658731,2184686.2133080973,358.81143576122531 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.184Z | Line | 5333549.6785361413,2184685.8678574199,358.81143576132604 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.195Z | Line | 5333549.5586064057,2184685.5224067392,358.81143576217596 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.204Z | Line | 5333549.4386766767,2184685.1769560608,358.81143576107746 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.216Z | Line | 5333549.0638099471,2184684.0971740657,358.85588584973186 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.226Z | Line | 5333548.9438802144,2184683.7517233863,358.85588584994525 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.235Z | Line | 5333548.8239504825,2184683.406272707,358.85588584973607 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.246Z | Line | 5333548.7040207507,2184683.0608220305,358.85588584963932 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.256Z | Line | 5333548.584091017,2184682.7153713489,358.85588584955224 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.267Z | Line | 5333548.2092242893,2184681.6355893523,358.85271084341133 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.278Z | Line | 5333548.0892945575,2184681.2901386749,358.85271084340712 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.288Z | Line | 5333547.9693648247,2184680.9446879961,358.85271084340297 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.299Z | Line | 5333547.8494350929,2184680.5992373205,358.85271084353042 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.309Z | Line | 5333547.7295053601,2184680.2537866416,358.8527108434734 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.319Z | Line | 5333547.3546386287,2184679.1740046451,358.80032323881937 | 0 | 0 | 0 | 0,0,0 | 0,9.3132257461547852e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.329Z | Line | 5333547.234708895,2184678.8285539639,358.80032323882944 | 0 | 0 | 0 | 0,0,0 | 0,9.3132257461547852e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.338Z | Line | 5333547.1147791632,2184678.4831032846,358.80032323883944 | 0 | 0 | 0 | 0,0,0 | 0,9.3132257461547852e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.348Z | Line | 5333546.9948494295,2184678.1376526039,358.80032323885376 | 0 | 0 | 0 | 0,0,0 | 0,9.3132257461547852e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.360Z | Line | 5333546.8749196939,2184677.7922019204,358.80032323953884 | 0 | 0 | 0 | 0,0,0 | 0,9.3132257461547852e-10,2.1336042672085682
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.370Z | Line | 5333546.500052969,2184676.7124199262,358.74793563378381 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672084545
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.381Z | Line | 5333549.9786547925,2184686.964672985,358.67173548060026 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386740297079,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.390Z | Line | 5333550.1036103684,2184687.3246003166,358.67173548127795 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386740297079,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.398Z | Line | 5333550.0433511799,2184686.9186861096,358.81143576109679 | 0 | 0 | 0 | 0,0,0 | 0,4.6566128730773926e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.410Z | Line | 5333549.2490247069,2184684.8630156051,358.67173548116591 | 0 | 0 | 0 | 0,-0.29989278269931674,0 | 0.86382386833429337,0,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.419Z | Line | 5333549.12406913,2184684.5030882736,358.67173548093768 | 0 | 0 | 0 | 0,-0.29989278316497803,0 | 0.86382386926561594,0,5.6843418860808015e-14
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.430Z | Line | 5333549.1887655174,2184684.4571013977,358.8558858491312 | 0 | 0 | 0 | -9.3132257461547852e-10,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.449Z | Line | 5333548.3944390435,2184682.4014308942,358.67173548072702 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386833429337,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.457Z | Line | 5333548.2694834685,2184682.0415035617,358.67173548072515 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.468Z | Line | 5333548.3341798605,2184681.9955166853,358.85271084298552 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.479Z | Line | 5333547.5481837587,2184679.9638413414,358.67173548033333 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386833429337,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.489Z | Line | 5333547.6045497786,2184679.893859311,358.85223347731647 | 0 | 0 | 0 | 0,-4.6566128730773926e-10,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.499Z | Line | 5333547.4148978079,2184679.5799188516,358.67173548084605 | 0 | 0 | 0 | 0,-0.2998927840963006,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.509Z | Line | 5333547.479594199,2184679.5339319762,358.80032323851123 | 0 | 0 | 0 | 0,0,0 | 0,9.3132257461547852e-10,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.519Z | Line | 5333546.6852677194,2184677.4782614699,358.67173548089733 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382387019693851,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.530Z | Line | 5333546.5603121538,2184677.1183341341,358.67173548118694 | 0 | 0 | 0 | 0,-0.29989278456196189,0 | 0.86382386926561594,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.538Z | Line | 5333546.6250085421,2184677.0723472605,358.74793563268912 | 0 | 0 | 0 | 0,0,0 | 0,0,2.1336042672085114
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.549Z | Line | 5333550.473314045,2184689.551212952,360.59507756639437 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:15.561Z | Line | 5333550.4790411759,2184689.5677096215,360.59479040154923 | 0 | 0 | 0 | 0,-0.12495518662035465,0 | 0.35992620419710875,0,0.002280584967707
