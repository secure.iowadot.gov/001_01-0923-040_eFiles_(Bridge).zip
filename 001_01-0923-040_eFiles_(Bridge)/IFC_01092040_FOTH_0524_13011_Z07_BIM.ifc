Properties of the parts of a building model (IFC4X3_ADD2), part 18 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.963Z | Extended Element | 5333562.704093813,2184679.1444297368,360.99640748610545 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.974Z | Extended Element | 5333562.5898067858,2184679.1427249736,360.99607325336854 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.985Z | Extended Element | 5333562.4755197614,2184679.1410202114,360.99573902059899 | -179.145 | -0.0000167875 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:45.993Z | Extended Element | 5333562.3612327334,2184679.1393154496,360.99540478787549 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.003Z | Extended Element | 5333562.2469457071,2184679.1376106879,360.99507055514295 | -179.145 | -0.0000232993 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.012Z | Extended Element | 5333562.1326586828,2184679.1359059247,360.9947363223925 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.023Z | Extended Element | 5333562.0183716556,2184679.1342011639,360.99440208965262 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.031Z | Extended Element | 5333561.9040846322,2184679.1324964017,360.99406785690547 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.044Z | Extended Element | 5333561.7897976041,2184679.130791639,360.99373362416935 | -179.145 | -0.0000167302 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.052Z | Extended Element | 5333561.6755105788,2184679.1290868768,360.99339939142078 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.061Z | Extended Element | 5333561.5612235507,2184679.1273821145,360.99306515866704 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.070Z | Extended Element | 5333561.4469365235,2184679.1256773523,360.99273092592989 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.080Z | Extended Element | 5333561.3326495001,2184679.1239725915,360.99239669319485 | -179.145 | -0.0000156587 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.095Z | Extended Element | 5333561.2183625354,2184679.1222678297,360.99204397650072 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.106Z | Extended Element | 5333561.1040759264,2184679.120563074,360.99158946646878 | -179.145 | -0.0000224411 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.115Z | Extended Element | 5333560.9897893155,2184679.1188583174,360.9911349564187 | -179.145 | -0.0000366428 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.126Z | Extended Element | 5333560.8755027037,2184679.1171535617,360.99068044637016 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.137Z | Extended Element | 5333560.761216091,2184679.1154488055,360.99022593632947 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.146Z | Extended Element | 5333560.6469294801,2184679.1137440489,360.98977142628729 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.158Z | Extended Element | 5333560.5326428711,2184679.1120392941,360.9893169162479 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.169Z | Extended Element | 5333560.4183562594,2184679.1103345384,360.9888624062072 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.177Z | Extended Element | 5333560.3040696485,2184679.1086297813,360.98840789616469 | -179.145 | -0.0000367001 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.189Z | Extended Element | 5333560.1897830376,2184679.1069250256,360.98795338610904 | -179.145 | -0.0000234139 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.197Z | Extended Element | 5333560.0754964249,2184679.1052202703,360.98749887606766 | -179.145 | -0.0000167302 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.209Z | Extended Element | 5333559.961209815,2184679.1035155132,360.9870443660177 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.218Z | Extended Element | 5333559.8469232032,2184679.1018107585,360.98658985598036 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.227Z | Extended Element | 5333559.7326365933,2184679.1001060028,360.98613534593738 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.237Z | Extended Element | 5333559.6183499806,2184679.0984012461,360.98568083589504 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.246Z | Extended Element | 5333559.5040633706,2184679.0966964904,360.98522632585195 | -179.145 | -0.0000223344 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.256Z | Extended Element | 5333559.3897767588,2184679.0949917343,360.98477181580012 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.267Z | Extended Element | 5333559.275490148,2184679.0932869781,360.9843173057692 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.277Z | Extended Element | 5333559.1612035362,2184679.0915822233,360.98386279572605 | -179.145 | -0.0000232499 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.287Z | Extended Element | 5333559.0469169244,2184679.0898774667,360.98340828568598 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.297Z | Extended Element | 5333558.9326303145,2184679.0881727114,360.98295377564074 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.308Z | Extended Element | 5333558.8183437027,2184679.0864679548,360.98249926558731 | -179.145 | -0.0000224905 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.319Z | Extended Element | 5333558.7040570918,2184679.0847631991,360.98204475553388 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.329Z | Extended Element | 5333558.5897704819,2184679.0830584429,360.98159024550557 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.340Z | Extended Element | 5333558.4754838683,2184679.0813536863,360.9811357354576 | -179.145 | -0.0000167875 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.349Z | Extended Element | 5333558.3611972583,2184679.079648931,360.98068122541457 | -179.145 | -0.000015708 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.360Z | Extended Element | 5333558.2469106494,2184679.0779441749,360.98022671537359 | -179.145 | -0.0000299751 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.371Z | Extended Element | 5333558.1326240366,2184679.0762394192,360.97977220532795 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.380Z | Extended Element | 5333558.0183374248,2184679.0745346635,360.97931769527833 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.391Z | Extended Element | 5333557.9040508131,2184679.0728299068,360.97886318523445 | -179.145 | -0.0000234632 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.401Z | Extended Element | 5333557.7897642031,2184679.0711251516,360.97840867519989 | -179.145 | -0.0000223265 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.411Z | Extended Element | 5333557.6754775904,2184679.0694203959,360.97795416514788 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.421Z | Extended Element | 5333557.5611909805,2184679.0677156392,360.97749965511605 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.431Z | Extended Element | 5333557.4469043696,2184679.066010884,360.97704514506938 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.442Z | Extended Element | 5333557.3326177597,2184679.0643061278,360.9765906350342 | -179.145 | -0.0000223917 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.453Z | Extended Element | 5333557.218331147,2184679.0626013721,360.97613612497486 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.462Z | Extended Element | 5333557.1040445352,2184679.0608966155,360.97568161493359 | -179.145 | -0.0000367001 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.473Z | Extended Element | 5333556.9897579243,2184679.0591918598,360.97522710488295 | -179.145 | -0.0000300245 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.482Z | Extended Element | 5333556.8754713135,2184679.0574871046,360.97477259484674 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.491Z | Extended Element | 5333556.7611847026,2184679.0557823475,360.97431808478728 | -179.145 | -0.0000167875 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.499Z | Extended Element | 5333556.6468980918,2184679.0540775922,360.97386357475898 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.508Z | Extended Element | 5333556.5326114828,2184679.052372836,360.97340906471504 | -179.145 | -0.0000366428 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.519Z | Extended Element | 5333556.4183248682,2184679.0506680799,360.97295455467463 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.528Z | Extended Element | 5333556.3040382592,2184679.0489633242,360.97250004461966 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.539Z | Extended Element | 5333556.1897516474,2184679.0472585689,360.97204553457067 | -179.145 | -0.0000167381 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.547Z | Extended Element | 5333556.0754650356,2184679.0455538123,360.97159102453338 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.558Z | Extended Element | 5333555.9611784229,2184679.0438490566,360.97113651448433 | -179.145 | -0.0000233486 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.569Z | Extended Element | 5333555.846891812,2184679.0421443004,360.97068200444892 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.578Z | Extended Element | 5333555.7326052031,2184679.0404395447,360.97022749439947 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.589Z | Extended Element | 5333555.6183185922,2184679.0387347881,360.96977298435348 | -179.145 | -0.0000290102 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.598Z | Extended Element | 5333555.5040319804,2184679.0370300324,360.96931847431239 | -179.145 | -0.0000300323 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.609Z | Extended Element | 5333555.3897453677,2184679.0353252767,360.96886396426913 | -179.145 | -0.0000300165 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.620Z | Extended Element | 5333555.2754587587,2184679.0336205214,360.96840945423355 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.629Z | Extended Element | 5333555.161172145,2184679.0319157648,360.96795494419774 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.640Z | Extended Element | 5333555.0468855361,2184679.0302110096,360.96750043414812 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.649Z | Extended Element | 5333554.9325989233,2184679.0285062524,360.96704592409623 | -179.145 | -0.0000367495 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.660Z | Extended Element | 5333554.8183123125,2184679.0268014967,360.96659141405291 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.669Z | Extended Element | 5333554.7040257035,2184679.0250967415,360.96613690401659 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.677Z | Extended Element | 5333554.5897390917,2184679.0233919853,360.96568239396635 | -179.145 | -0.0000233566 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.688Z | Extended Element | 5333554.4754524799,2184679.0216872292,360.96522788391439 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.697Z | Extended Element | 5333554.3611658672,2184679.0199824725,360.96477337387699 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.706Z | Extended Element | 5333554.2468792573,2184679.0182777178,360.96431886383311 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.716Z | Extended Element | 5333554.1325926473,2184679.0165729616,360.96386435379361 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.726Z | Extended Element | 5333554.0183060374,2184679.0148682054,360.96340984374643 | -179.145 | -0.0000223917 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.736Z | Extended Element | 5333553.9040194228,2184679.0131634502,360.96295533370113 | -179.145 | -0.0000300165 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.746Z | Extended Element | 5333553.7897328129,2184679.011458694,360.96250082366902 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.764Z | Extended Element | 5333553.675446325,2184679.0097539397,360.96201655076112 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.774Z | Extended Element | 5333553.5611599181,2184679.0080491863,360.96151362241721 | -179.145 | -0.0000300323 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.787Z | Extended Element | 5333553.4468735103,2184679.0063444343,360.96101069408877 | -179.145 | -0.0000300245 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.797Z | Extended Element | 5333553.3325871006,2184679.004639681,360.96050776575186 | -179.145 | -0.0000299671 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.809Z | Extended Element | 5333553.2183006927,2184679.002934929,360.96000483740937 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.820Z | Extended Element | 5333553.1040142849,2184679.0012301756,360.95950190907223 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.830Z | Extended Element | 5333552.9897278761,2184678.9995254227,360.95899898072082 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.840Z | Extended Element | 5333552.8754414674,2184678.9978206689,360.95849605238533 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.850Z | Extended Element | 5333552.7611550586,2184678.9961159169,360.95799312405728 | -179.145 | -0.0000233566 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.858Z | Extended Element | 5333552.6468686508,2184678.9944111635,360.95749019570098 | -179.145 | -0.0000299751 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.868Z | Extended Element | 5333552.532582242,2184678.9927064106,360.95698726737049 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.879Z | Extended Element | 5333552.4182958333,2184678.9910016581,360.95648433902659 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.888Z | Extended Element | 5333552.3040094273,2184678.9892969048,360.95598141068933 | -179.145 | -0.0000223917 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.898Z | Extended Element | 5333552.1897230176,2184678.9875921514,360.95547848233275 | -179.145 | -0.0000224411 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.909Z | Extended Element | 5333552.0754366098,2184678.9858873994,360.95497555401045 | -179.145 | -0.0000157574 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.917Z | Extended Element | 5333551.961150201,2184678.9841826465,360.95447262567779 | -179.145 | -0.0000223265 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.926Z | Extended Element | 5333551.8468637932,2184678.9824778927,360.95396969733673 | -179.145 | -0.000015716 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.935Z | Extended Element | 5333551.7325773844,2184678.9807731402,360.95346676899629 | -179.145 | -0.0000289528 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.945Z | Extended Element | 5333551.6182909776,2184678.9790683878,360.95296384065097 | -179.145 | -0.0000290022 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.955Z | Extended Element | 5333551.5040045688,2184678.9773636349,360.95246091231138 | -179.145 | -0.0000223838 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.964Z | Extended Element | 5333551.3897181582,2184678.9756588819,360.95195798396583 | -179.145 | -0.0000167875 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.975Z | Extended Element | 5333551.2754317522,2184678.9739541295,360.95145505563028 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.985Z | Extended Element | 5333551.1611453416,2184678.9722493752,360.95095212730143 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:46.994Z | Extended Element | 5333551.0468589328,2184678.9705446227,360.95044919893621 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.003Z | Extended Element | 5333550.9325725269,2184678.9688398703,360.94994627061129 | -179.145 | -0.000030131 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.012Z | Extended Element | 5333550.8182861162,2184678.9671351174,360.94944334227148 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.022Z | Extended Element | 5333550.7039997093,2184678.9654303649,360.94894041393201 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.031Z | Extended Element | 5333550.5897133006,2184678.9637256116,360.94843748559214 | -179.145 | -0.0000300245 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.041Z | Extended Element | 5333550.4754268927,2184678.9620208587,360.94793455726852 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.050Z | Extended Element | 5333550.361140484,2184678.9603161057,360.94743162889733 | -179.145 | -0.0000300243 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.062Z | Extended Element | 5333550.2468540752,2184678.9586113528,360.94692870057048 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.071Z | Extended Element | 5333550.1325676655,2184678.9569065995,360.94642577223567 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.080Z | Extended Element | 5333550.0182812586,2184678.9552018475,360.9459228438833 | -179.145 | -0.0000232993 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.089Z | Extended Element | 5333549.903994849,2184678.9534970946,360.9454199155544 | -179.145 | -0.0000299671 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.099Z | Extended Element | 5333549.7897084402,2184678.9517923412,360.94491698722345 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.108Z | Extended Element | 5333549.6754220352,2184678.9500875883,360.94441405888688 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.119Z | Extended Element | 5333549.5611356245,2184678.9483828354,360.94391113053581 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.129Z | Extended Element | 5333549.4468492167,2184678.9466780829,360.9434082021902 | -179.145 | -0.0000367415 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.141Z | Extended Element | 5333549.332562807,2184678.94497333,360.94290527385152 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.150Z | Extended Element | 5333549.2182763992,2184678.9432685771,360.94240234552461 | -179.145 | -0.0000301232 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.158Z | Extended Element | 5333549.1039899914,2184678.9415638237,360.94189941718048 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.167Z | Extended Element | 5333548.9897035826,2184678.9398590717,360.941396488843 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.177Z | Extended Element | 5333548.8754171757,2184678.9381543184,360.94089356048841 | -179.145 | -0.0000224411 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.186Z | Extended Element | 5333548.7611307651,2184678.9364495645,360.94039063216059 | -179.145 | -0.0000291089 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.196Z | Extended Element | 5333548.6468443591,2184678.9347448135,360.93988770384141 | -179.145 | -0.0000167795 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.205Z | Extended Element | 5333548.5325579494,2184678.9330400596,360.93938477548022 | -179.145 | -0.0000234474 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.215Z | Extended Element | 5333548.4182715416,2184678.9313353067,360.93888184712779 | -179.145 | -0.0000235047 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.226Z | Extended Element | 5333548.303985131,2184678.9296305538,360.93837891879957 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.237Z | Extended Element | 5333548.1896987241,2184678.9279258009,360.93787599045015 | -179.145 | -0.0000234552 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.246Z | Extended Element | 5333548.0754123162,2184678.9262210475,360.93737306211 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.256Z | Extended Element | 5333547.9611259075,2184678.9245162951,360.93687013376001 | -179.145 | -0.000023406 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.266Z | Extended Element | 5333547.8468394978,2184678.9228115412,360.9363672054356 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.276Z | Extended Element | 5333547.73255309,2184678.9211067893,360.93586427710869 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.287Z | Extended Element | 5333547.6182666812,2184678.9194020364,360.93536134875717 | -179.145 | -0.0000301804 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.295Z | Extended Element | 5333547.5039802743,2184678.9176972834,360.93485842042122 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.308Z | Extended Element | 5333547.3896938683,2184678.9159925305,360.93435549208255 | -179.145 | -0.000030123 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.317Z | Extended Element | 5333547.2754074568,2184678.9142877776,360.9338525637387 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.329Z | Line String | 5333547.205443928,2184675.941108366,360.88235884733234 | 0 | 0 | 0 | -0.040914447978138924,0,0 | 0,2.7428996101953089,0.046418669234924437
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.355Z | Extended Element | 5333547.164529481,2184678.6840079757,360.92877751656579 | -179.145 | -0.0000158517 | -1.14576 | -0.014347853094685125,-9.7219959705793419e-11,-0.1215127137779678 | 0.014347901848453816,2.7495508287665253,0.021456557715218174
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.363Z | Line String | 5333547.0911564147,2184675.9394035968,360.88185592623921 | 0 | 0 | 0 | -0.035989562049508095,0,0 | 0,2.4127356791868806,0.039814645065689547
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.392Z | Extended Element | 5333547.0551668527,2184678.352139276,360.921670571302 | -179.145 | -0.0000121435 | -1.14576 | -0.014347870709960976,-2.3642076109735297e-10,-0.12151275767917512 | 0.014347852926957503,2.4192841342629654,0.021456512016988699
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.402Z | Line String | 5333546.9768689014,2184675.9376988276,360.88135300544832 | 0 | 0 | 0 | -0.031443511135876179,0,0 | 0,2.1079689729958773,0.033718622736785164
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.429Z | Extended Element | 5333546.9454253893,2184678.0456678011,360.91507162818988 | -179.145 | -0.00000110411 | -1.14576 | -0.014347852711963632,-1.0778020488401092e-10,-0.12151275881569472 | 0.014347857830016174,2.1144225710107967,0.021456511292081707
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.439Z | Line String | 5333546.8625813872,2184675.9359940584,360.88085008454772 | 0 | 0 | 0 | -0.026518621481955051,0,0 | 0,1.7778050424531102,0.027114598537082202
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.463Z | Extended Element | 5333546.8360627666,2184677.7137991013,360.90796468308815 | -179.145 | 0.00000165465 | -1.14576 | -0.014347884444553299,-2.8343094516352843e-10,-0.12151275963104829 | 0.014347852887569556,1.7841558768650305,0.021456510535961298
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.474Z | Line String | 5333546.7482938739,2184675.9342892887,360.880347163637 | 0 | 0 | 0 | -0.021972568705677986,0,0 | 0,1.4730383357964456,0.02101857620834835
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.499Z | Extended Element | 5333546.7263213051,2184677.407327624,360.90136573983466 | -179.145 | -0.0000034719 | -1.14576 | -0.014347852521044493,-3.9992229843366967e-10,-0.1215127624185621 | 0.014347916872382273,1.4792943130436458,0.021456508477665306
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.509Z | Line String | 5333546.6340063615,2184675.9325845195,360.87984424275561 | 0 | 0 | 0 | -0.017426518723368645,0,0 | 0,1.1682716300711036,0.014922553879387124
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.534Z | Extended Element | 5333546.6165798418,2184677.1008561496,360.89476679663841 | -179.145 | -0.0000012346 | -1.14576 | -0.014347876015358639,-2.2281604794174995e-10,-0.12151271253826544 | 0.014347852710266531,1.1744327504779031,0.021456557221344191
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.544Z | Line String | 5333546.5197188482,2184675.9308797508,360.87934132182329 | 0 | 0 | 0 | -0.012501629069447517,0,0 | 0,0.83810769952833652,0.0083185296796841612
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.571Z | Extended Element | 5333546.5072172191,2184676.7689874507,360.8876598515057 | -179.145 | -0.00000579857 | -1.14576 | -0.014347850696282263,5.2172289174774716e-11,-0.12151270955210212 | 0.014347875077059933,0.84416605676614831,0.021456560469766343
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.579Z | Line String | 5333546.4054313339,2184675.9291749815,360.87883840065928 | 0 | 0 | 0 | -0.0079555772244930267,0,0 | 0,0.53334099426865578,0.0022225073508366222
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.600Z | Extended Element | 5333546.40317534,2184676.0804135893,360.76453817708926 | -179.145 | 0.000023301 | -0.00000185339 | -0.014334897563160689,-0.38233610804778295,-0.01433489688627229 | 0.01433489982415972,0.15606532632081441,0.12863512628103288
Complex Shape | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.609Z | Complex Shape | 5333546.3466998488,2184676.5030389894,360.6816402750718 | 0 | 0 | 0 | -0.053189978934824467,-0.15321066742762923,0 | 4.6275281626731157,13.329328022897243,0.41244063437130762
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.635Z | Extended Element | 5333606.3908937881,2184677.2483184761,360.93012733594588 | -89.1454 | 0.00000700484 | 179.873 | -0.014496082318540493,-6.0776909845632524e-10,-0.014496162064830594 | 0.01449608161067972,60.103420779105377,0.22050473309618188
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.649Z | Extended Element | 0,0,0 | 0 | 0 | 0 | 5333546.3406955097,2184676.3323629065,360.68083559563894 | 5333551.0230229916,2184689.8165109297,361.09488558144307
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.660Z | Complex Chain | 5333550.9742280049,2184689.8323669932,360.97922636254185 | 0 | 0 | 0 | -4.6807181350886822,-13.48253867123276,-0.021477599138506775 | 0,0,0.11485454690125607
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.670Z | Bspline Curve | 5333550.9829412717,2184689.2482308066,360.97922636254259 | 0 | 0 | 0 | 0,0,0 | 59.827677903696895,0.89241939643397927,0.083478415948538887
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.678Z | Bspline Curve | 5333551.0194517532,2184686.8005732014,360.97922636254606 | 0 | 0 | 0 | 0,0,0 | 58.936803388409317,0.87913066847249866,0.083478415948538887
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.689Z | Bspline Curve | 5333551.0559622329,2184684.3529155958,360.97922636254953 | 0 | 0 | 0 | 0,0,0 | 58.045928874984384,0.86584194144234061,0.083478415948538887
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.696Z | Bspline Curve | 5333551.0924727125,2184681.9052579906,360.97922636255299 | 0 | 0 | 0 | 0,0,0 | 57.155054361559451,0.85255321441218257,0.083478415948538887
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.706Z | Bspline Curve | 5333551.1289831921,2184679.457600385,360.9792263625564 | 0 | 0 | 0 | 0,0,0 | 56.264179847203195,0.83926448691636324,0.083478415948558024
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.714Z | Bspline Curve | 5333551.1654936727,2184677.0099427798,360.97922636255987 | 0 | 0 | 0 | 0,0,0 | 55.37330533284694,0.82597575942054391,0.083478415948558024
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.726Z | Line | 5333590.3908299133,2184683.713965252,361.18641939236079 | 0 | 0 | 0 | 0,0,-0.10318770637547914 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.734Z | Line | 5333548.6338689364,2184683.0910976566,361.09383684562141 | 0 | 0 | 0 | 0,0,-0.2231361520452424 | 1.862645149230957e-09,9.3132257461547852e-10,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.746Z | Line | 5333608.731587748,2184683.9875451182,361.15029888878541 | 0 | 0 | 0 | 0,0,-0.22313615115621133 | 2.7939677238464355e-09,5.5879354476928711e-09,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.755Z | Line String | 5333561.4765647165,2184689.5063704178,360.92830456314596 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.021909571952335227
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.764Z | Line String | 5333561.4056447456,2184689.3020895282,360.93212005174314 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891912207007,0.021989190408191917
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.774Z | Line String | 5333561.318656968,2184689.0515262508,360.93678445572249 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.1144089181907475,0.022086847421576294
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.782Z | Line String | 5333561.2167095086,2184688.7578724725,360.94225043447875 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891912207007,0.022201298954257709
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.792Z | Line String | 5333561.1147620492,2184688.4642186952,360.94772173540974 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891865640879,0.022315750486029629
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.802Z | Line String | 5333561.0128145888,2184688.1705649178,360.95319303553492 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.022430202017687861
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.812Z | Line String | 5333560.9108671295,2184687.8769111396,360.95866650525903 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.022544653549402938
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.823Z | Line String | 5333560.8089196701,2184687.5832573622,360.96413563418258 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.022659105082084352
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.832Z | Line String | 5333560.7069722107,2184687.2896035844,360.96960693276509 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.022773556614936297
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.841Z | Line String | 5333560.6222006828,2184687.0454240846,360.97415812920406 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.0228687255520299
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.850Z | Line String | 5333560.5512807108,2184686.841143196,360.97796255650906 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.022948344009648736
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.860Z | Line String | 5333560.4642929332,2184686.5905799177,360.98263100107062 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.023046001023089957
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.870Z | Line String | 5333560.3623454738,2184686.2969261403,360.98812398310997 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.02316045255474819
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.879Z | Line String | 5333560.2603980144,2184686.0032723625,360.99357359643886 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.02327490408652011
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.890Z | Line String | 5333560.1584505551,2184685.7096185847,360.99904489373245 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.023389355618178342
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.899Z | Line String | 5333560.0565030957,2184685.4159648074,361.0044977557173 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891772508621,0.02351474391798547
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.910Z | Line String | 5333559.9545556363,2184685.12231103,361.00994616269571 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891772508621,0.02362919545026898
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.920Z | Line String | 5333559.8526081769,2184684.8286572518,361.01539456913076 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.023743646983518829
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.930Z | Line String | 5333559.767836649,2184684.5844777515,361.01992503757208 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891865640879,0.023838815921124024
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.940Z | Line String | 5333559.6969166771,2184684.3801968629,361.02372003503604 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.023918434379140763
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.949Z | Line String | 5333559.6099288994,2184684.129633585,361.02832990610995 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024016091391956707
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.958Z | Line String | 5333559.5079814401,2184683.8359798072,361.03280873777197 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024130542925263399
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.967Z | Line String | 5333559.4060339807,2184683.5423260299,361.03535179256477 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.024244994457546909
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.978Z | Line String | 5333559.3040865213,2184683.2486722521,361.03591451456111 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024359445989773576
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.988Z | Line String | 5333557.1327164471,2184676.9941659686,360.9114685291932 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.026819012753719562
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:47.998Z | Line String | 5333557.203636419,2184677.1984468573,360.91585922727563 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.026731198090089947
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.008Z | Line String | 5333557.2906241976,2184677.4490101356,360.92118107842816 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891865640879,0.026630800515818009
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.019Z | Line String | 5333557.392571657,2184677.7426639134,360.92743958672747 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891865640879,0.02651634898404609
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.027Z | Line String | 5333557.4945191164,2184678.0363176912,360.93369809493652 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.026401897452217327
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.039Z | Line String | 5333557.5964665748,2184678.3299714685,360.9399566032539 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.026287445919422225
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.047Z | Line String | 5333557.6984140342,2184678.6236252463,360.94621511161472 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.026172994386627124
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.058Z | Line String | 5333557.8003614936,2184678.9172790241,360.9524736199665 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.026058542854741518
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.070Z | Line String | 5333557.902308953,2184679.2109328015,360.95873212829002 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.025944091322969598
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.080Z | Line String | 5333557.9870804809,2184679.4551123017,360.9639362140191 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.025848922384739126
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.090Z | Line String | 5333558.0580004537,2184679.6593931904,360.9683820556026 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.025769303928086629
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.100Z | Line String | 5333558.1449882314,2184679.9099564687,360.97363009898396 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.025671646913622226
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.110Z | Line String | 5333558.2469356908,2184680.2036102461,360.97988860802633 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.025557195382816644
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.119Z | Line String | 5333558.3488831501,2184680.4972640234,360.9861471162809 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.025442743850021543
