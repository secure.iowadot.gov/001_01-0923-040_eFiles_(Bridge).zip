Properties of the parts of a building model (IFC4X3_ADD2), part 19 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.127Z | Line String | 5333558.4508306086,2184680.7909178017,360.99240562409642 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.025328292316146417
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.138Z | Line String | 5333558.552778068,2184681.084571579,360.99866413233008 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.025213840782271291
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.146Z | Line String | 5333558.6547255274,2184681.3782253568,361.0049226403026 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.025093504254925847
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.155Z | Line String | 5333558.7566729868,2184681.6718791346,361.01116331005545 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024974000949384845
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.164Z | Line String | 5333558.8414445156,2184681.9160586344,361.01638005109231 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.02487883201177965
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.175Z | Line String | 5333558.9123644885,2184682.120339524,361.02069951604557 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.1144089181907475,0.024799213554558719
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.183Z | Line String | 5333558.9993522661,2184682.3709028023,361.0259710723621 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.1144089181907475,0.024701556539753255
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.193Z | Line String | 5333559.1012997255,2184682.6645565797,361.03122896927709 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.1144089181907475,0.024587105007412902
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.203Z | Line String | 5333559.2032471849,2184682.958210357,361.03456676752756 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.024472653474219896
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.211Z | Line String | 5333592.5627550147,2184689.9700674913,360.96563147132417 | 0 | 0 | 0 | 0,0,-0.011788822054427328 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.221Z | Line String | 5333592.4918350438,2184689.7657866022,360.96978135743643 | 0 | 0 | 0 | 0,0,-0.011709203598456952 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.229Z | Line String | 5333592.4048472652,2184689.5152233243,360.9748559208727 | 0 | 0 | 0 | 0,0,-0.011611546584958887 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.239Z | Line String | 5333592.3028998058,2184689.2215695465,360.98080259606735 | 0 | 0 | 0 | 0,0,-0.011497095051993256 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.247Z | Line String | 5333592.2009523464,2184688.9279157687,360.98675459343258 | 0 | 0 | 0 | 0,0,-0.011382643520050806 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.255Z | Line String | 5333592.099004887,2184688.6342619909,360.99270599821728 | 0 | 0 | 0 | 0,0,-0.01126760021361406 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.268Z | Line String | 5333591.9970574277,2184688.3406082136,360.9986372740691 | 0 | 0 | 0 | 0,0,-0.011142803689267566 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.276Z | Line String | 5333591.8951099683,2184688.0469544362,361.00456420912428 | 0 | 0 | 0 | 0,0,-0.011028352156074561 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.286Z | Line String | 5333591.7931625089,2184687.753300658,361.01049331383865 | 0 | 0 | 0 | 0,0,-0.010913900623052086 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.295Z | Line String | 5333591.708390981,2184687.5091211582,361.01542518602685 | 0 | 0 | 0 | 0,0,-0.010818731685560579 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.304Z | Line String | 5333591.637471009,2184687.3048402695,361.01954808716295 | 0 | 0 | 0 | 0,0,-0.010739113227600683 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.314Z | Line String | 5333591.5504832305,2184687.0542769912,361.02460715977878 | 0 | 0 | 0 | 0,0,-0.010641456213932088 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.324Z | Line String | 5333591.4485357711,2184686.7606232138,361.03055794794574 | 0 | 0 | 0 | 0,0,-0.010527004681819108 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.332Z | Line String | 5333591.3465883126,2184686.4669694365,361.03646536740234 | 0 | 0 | 0 | 0,0,-0.010412553149706127 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.341Z | Line String | 5333591.2446408533,2184686.1733156582,361.04239447082358 | 0 | 0 | 0 | 0,0,-0.010298101617536304 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.350Z | Line String | 5333591.1426933939,2184685.8796618809,361.04832357386971 | 0 | 0 | 0 | 0,0,-0.010183650084513829 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.361Z | Line String | 5333591.0407459345,2184685.5860081031,361.0542526772827 | 0 | 0 | 0 | 0,0,-0.010069198552400849 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.371Z | Line String | 5333590.9387984751,2184685.2923543258,361.0601817801566 | 0 | 0 | 0 | 0,0,-0.009954747019264687 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.380Z | Line String | 5333590.8540269472,2184685.0481748255,361.06511195813505 | 0 | 0 | 0 | 0,0,-0.0098595780817163359 | 7.6699587125331163,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.391Z | Line String | 5333590.7831069753,2184684.8438939368,361.0692413531221 | 0 | 0 | 0 | 0,0,-0.009779959623870127 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.400Z | Line String | 5333590.6961191967,2184684.593330659,361.07426138364912 | 0 | 0 | 0 | 0,0,-0.0096823026111678701 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.409Z | Line String | 5333590.5941717373,2184684.2996768812,361.07921056401631 | 0 | 0 | 0 | 0,0,-0.0095575033444106339 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.417Z | Line String | 5333590.4922242779,2184684.0060231034,361.08221142493733 | 0 | 0 | 0 | 0,0,-0.0094424627795319793 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.425Z | Line String | 5333590.3902768195,2184683.712369326,361.0832319530619 | 0 | 0 | 0 | 0,0,-0.0093280112477032162 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.434Z | Line String | 5333588.2189067453,2184677.4578630426,360.96868665186889 | 0 | 0 | 0 | 0,0,-0.006879381250030292 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.444Z | Line String | 5333588.2898267172,2184677.6621439317,360.97274295243267 | 0 | 0 | 0 | 0,0,-0.0069589997068533194 | 7.6699587125331163,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.454Z | Line String | 5333588.3768144948,2184677.9127072101,360.97767143496696 | 0 | 0 | 0 | 0,0,-0.0070566567215450959 | 7.6699587143957615,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.462Z | Line String | 5333588.4787619542,2184678.2063609874,360.98347213713834 | 0 | 0 | 0 | 0,0,-0.0071711082536580761 | 7.6699587143957615,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.472Z | Line String | 5333588.5807094136,2184678.5000147647,360.98927283921938 | 0 | 0 | 0 | 0,0,-0.0072855597857142129 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.480Z | Line String | 5333588.682656873,2184678.7936685425,360.99507354140485 | 0 | 0 | 0 | 0,0,-0.0074000113187935312 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.492Z | Line String | 5333588.7846043324,2184679.0873223203,361.00087424363363 | 0 | 0 | 0 | 0,0,-0.007514462851929693 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.501Z | Line String | 5333588.8865517918,2184679.3809760977,361.00667494585741 | 0 | 0 | 0 | 0,0,-0.0076289143839858298 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.514Z | Line String | 5333588.9884992512,2184679.6746298755,361.012475648053 | 0 | 0 | 0 | 0,0,-0.00774336591609881 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.525Z | Line String | 5333589.0732707791,2184679.9188093753,361.01729905802853 | 0 | 0 | 0 | 0,0,-0.0078385348546134992 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.535Z | Line String | 5333589.144190751,2184680.1230902639,361.02142642578474 | 0 | 0 | 0 | 0,0,-0.0079213023669240101 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.545Z | Line String | 5333589.2311785286,2184680.3736535423,361.02627209741615 | 0 | 0 | 0 | 0,0,-0.008026747092799269 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.555Z | Line String | 5333589.333125988,2184680.6673073196,361.03204991002832 | 0 | 0 | 0 | 0,0,-0.0081411986236048506 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.564Z | Line String | 5333589.4350734474,2184680.9609610979,361.03782772184439 | 0 | 0 | 0 | 0,0,-0.0082556501566273255 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.577Z | Line String | 5333589.5370209068,2184681.2546148752,361.04360553321698 | 0 | 0 | 0 | 0,0,-0.0083701016903887648 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.588Z | Line String | 5333589.6389683662,2184681.548268653,361.04938334500781 | 0 | 0 | 0 | 0,0,-0.0084845532243775779 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.598Z | Line String | 5333589.7409158256,2184681.8419224308,361.05516115654177 | 0 | 0 | 0 | 0,0,-0.0085990047572295225 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.609Z | Line String | 5333589.842863285,2184682.1355762086,361.06093896839008 | 0 | 0 | 0 | 0,0,-0.0087134562900814672 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.621Z | Line String | 5333589.9276348138,2184682.3797557084,361.06577503367731 | 0 | 0 | 0 | 0,0,-0.008808625227459288 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.630Z | Line String | 5333589.9985547857,2184682.5840365975,361.06977602480231 | 0 | 0 | 0 | 0,0,-0.0088882436843391588 | 7.6699587125331163,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.641Z | Line String | 5333590.0855425633,2184682.8345998758,361.0746569530603 | 0 | 0 | 0 | 0,0,-0.0089859006988604051 | 7.6699587143957615,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.649Z | Line String | 5333590.1874900227,2184683.1282536532,361.07945704384696 | 0 | 0 | 0 | 0,0,-0.0091003522306891682 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.660Z | Line String | 5333590.2894374821,2184683.421907431,361.08233703596528 | 0 | 0 | 0 | 0,0,-0.0092148037636547997 | 7.6699587134644389,0.11440891865640879,0
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.688Z | Extended Element | 5333569.1465234309,2184689.6207793364,360.95021413509568 | -89.1454 | -0.000086695 | -179.862 | -0.012700000154758254,-1.0976418175821012e-10,-0.012700000001127532 | 0.012700003902004367,7.6708561541785549,0.016119795190665101
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.718Z | Extended Element | 5333569.0756034572,2184689.4164984473,360.95410924214997 | -89.1454 | -0.000173692 | -179.862 | -0.012700000089519497,9.2313157100497658e-11,-0.01270000000034106 | 0.012700007539875047,7.6708563470207229,0.016199413410275348
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.747Z | Extended Element | 5333568.9886156814,2184689.165935169,360.95887130314219 | -89.1454 | -0.000020215 | -179.862 | -0.012699999928604764,-3.7055885702261622e-10,-0.012700000004623502 | 0.012700001994009297,7.6708565811640455,0.016297070139418713
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.773Z | Extended Element | 5333568.8866682211,2184688.8722813912,360.96445173343062 | -89.1454 | -0.00021876 | -179.862 | -0.012700000066220012,-1.7481477210363695e-11,-0.012700000003827294 | 0.012700009953266818,7.6708568561756376,0.016411521338549676
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.800Z | Extended Element | 5333568.7847207636,2184688.5786276134,360.97003748589742 | -89.1454 | -0.000102531 | -179.862 | -0.012700000048637385,-4.7938340591266086e-10,-0.012700000002605676 | 0.012700005440143658,7.670857132279596,0.016525972540053838
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.830Z | Extended Element | 5333568.6827733014,2184688.284973836,360.97562323755187 | -89.1454 | -0.0000869791 | -179.862 | -0.01269999981100715,-4.1866485076029078e-11,-0.012699999999772629 | 0.012700004236209787,7.6708574073723694,0.016640423733265675
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.859Z | Extended Element | 5333568.5808258448,2184687.9913200587,360.9812111588048 | -89.1454 | -0.0000661957 | -179.862 | -0.012700000043841597,-4.0799683323217718e-11,-0.012700000008608103 | 0.012700004260560208,7.6708576848997883,0.01675487495138522
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.886Z | Extended Element | 5333560.808919671,2184687.5832573622,360.96413563418452 | -89.1454 | 180 | -0.199785 | -0.012700009288036209,5.632544076441985e-10,-0.012700000002931361 | 0.012700000018810581,7.6708580059349245,0.016788427710514354
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.910Z | Extended Element | 5333560.7069722107,2184687.2896035844,360.96960693276526 | -89.1454 | 180 | -0.199785 | -0.012700001264407425,1.9714740941954899e-10,-0.012700000000113688 | 0.012700000166104066,7.6708584051546502,0.016673976867574592
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.935Z | Extended Element | 5333560.6222006828,2184687.0454240846,360.97415812920417 | -89.1454 | 180 | -0.199785 | -0.012700004666195261,3.8203925554341687e-10,-0.012700000002969442 | 0.01270000010757818,7.6708587372212937,0.016578808514805216
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.964Z | Extended Element | 5333560.5512807127,2184686.841143196,360.97796255651025 | -89.1454 | 180 | -0.199785 | -0.012700009178828695,-4.8114840647241206e-10,-0.012700000002939155 | 0.012700000125861368,7.6708590129233665,0.016499190548467511
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:48.993Z | Extended Element | 5333560.4642929351,2184686.5905799181,360.98263100107005 | -89.1454 | 180 | -0.199785 | -0.012700001516981117,1.3110657281354693e-10,-0.012700000008012141 | 0.012699999923360298,7.6708593530459099,0.016401534134170889
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.018Z | Extended Element | 5333560.3623454738,2184686.2969261408,360.98812398311179 | -89.1454 | 180 | -0.199785 | -0.012700004446112514,-6.0861464062565721e-11,-0.012700000004862476 | 0.012700000092012125,7.6708597533967877,0.016287083298061309
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.045Z | Extended Element | 5333560.2603980135,2184686.0032723621,360.99357359642875 | -89.1454 | 180 | -0.199785 | -0.012700003667867409,-3.2428195169797664e-10,-0.012700000012403356 | 0.012700000365792359,7.6708601536743508,0.016172632458230324
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.071Z | Extended Element | 5333560.158450556,2184685.7096185847,360.99904489373483 | -89.1454 | 180 | -0.199785 | -0.01270000303065315,7.0586766338430304e-11,-0.012700000000625272 | 0.012699999849378312,7.6708605517494579,0.016058181608629957
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.098Z | Extended Element | 5333567.7264618101,2184685.5303737251,361.02801249963835 | -89.1454 | 0.000239585 | -179.85 | -0.012700012049598046,3.5808320502386657e-10,-0.012700000005203422 | 0.012699999878413361,7.6708609287235499,0.016073404357221301
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.125Z | Extended Element | 5333567.6245143507,2184685.2367199478,361.03357535814746 | -89.1454 | 0.0000789281 | -179.85 | -0.012700003872934752,3.8876080128145244e-10,-0.012700000000852654 | 0.01269999994176256,7.6708612282044255,0.016187855478702572
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.150Z | Extended Element | 5333567.5225668913,2184684.9430661709,361.03913821611462 | -89.1454 | 0.000182502 | -179.85 | -0.012700009983607102,4.1305882990021397e-10,-0.012700000002090026 | 0.012700000025526039,7.6708615295897591,0.016302306628806506
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.177Z | Extended Element | 5333567.4377953615,2184684.6988866697,361.04376385349389 | -89.1454 | 0.0000392159 | -179.85 | -0.012700002814631782,8.6110226755181395e-10,-0.012700000003457942 | 0.012699999812674405,7.6708617789494093,0.016397475228668964
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.206Z | Extended Element | 5333567.3668753933,2184684.494605782,361.0476384694191 | -89.1454 | 0.0000511174 | -179.85 | -0.012700003119672894,3.4284331014443343e-10,-0.01270000000300182 | 0.012699999984782544,7.6708619901469186,0.016477093435711181
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.231Z | Extended Element | 5333567.2798876138,2184684.2440425041,361.05234599750378 | -89.1454 | 0.0000888378 | -179.85 | -0.01270000663727208,-1.3369561017376436e-10,-0.012700000000397907 | 0.012700000276866717,7.6708622452523851,0.016574750094524457
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.258Z | Extended Element | 5333567.1779401554,2184683.9503887263,361.05693928070298 | -89.1454 | 0.000380199 | -179.85 | -0.012700019468353243,4.0077267698778287e-10,-0.012699999999943161 | 0.012700000097549251,7.6708625461943454,0.016689201237007161
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.282Z | Extended Element | 5333567.0759926941,2184683.656734948,361.05959678702447 | -89.1454 | 0.000196806 | -179.85 | -0.012700009999871019,5.2057738434111234e-11,-0.012699999999033663 | 0.012700000031331378,7.670862844345768,0.016803652374356628
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.309Z | Extended Element | 5333559.3040865203,2184683.2486722521,361.03591451456003 | -89.1454 | -180 | -0.212121 | -0.012700000043535815,3.8613822918216704e-10,-0.012700000007867935 | 0.012700005452210552,7.6708632442762514,0.016739645143748299
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.335Z | Extended Element | 5333559.2032471858,2184682.958210357,361.03456676752546 | -89.1454 | -180 | -0.212121 | -0.01269999990493665,3.1691582682106535e-10,-0.012699999999545256 | 0.012700012492829465,7.6708636619094133,0.01662643844983942
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.361Z | Extended Element | 5333559.1012997264,2184682.6645565792,361.03122896927982 | -89.1454 | -180 | -0.212121 | -0.012699999916080996,5.7106066993270335e-10,-0.012700000006280233 | 0.012700006759326619,7.670864083693326,0.016511987701565499
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.385Z | Extended Element | 5333558.999352267,2184682.3709028033,361.0259710723634 | -89.1454 | -180 | -0.212121 | -0.012700002814631782,8.6110226755181395e-10,-0.012700000003457942 | 0.012699999812674405,7.6708617789494093,0.016397475228668964
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.413Z | Extended Element | 5333558.9123644875,2184682.120339524,361.02069951604608 | -89.1454 | -180 | -0.212121 | -0.012700000831469684,1.4470685802635766e-10,-0.012700000001705302 | 0.01270000014455162,7.6708648700429567,0.016299880580450093
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.441Z | Extended Element | 5333558.8414445166,2184681.9160586353,361.01638005108907 | -89.1454 | -180 | -0.212121 | -0.012700000662830781,4.5624103972361218e-10,-0.012700000006226399 | 0.012700004599777451,7.6708651669470846,0.016220262677017878
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.466Z | Extended Element | 5333558.7566729877,2184681.6718791351,361.01116331005096 | -89.1454 | -180 | -0.212121 | -0.012700000085086651,-6.0063332091315448e-10,-0.012700000001818992 | 0.012700003252773463,7.6708655168415545,0.016125094374002443
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.492Z | Extended Element | 5333558.6547255283,2184681.3782253577,361.00492264030424 | -89.1454 | -180 | -0.212308 | -0.01270000064778092,-2.6722776623672868e-10,-0.012700000001672467 | 0.012700004594465247,7.6708659906503094,0.016030633339358481
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.518Z | Extended Element | 5333566.2227367824,2184681.1989804977,361.02387797311223 | -89.1454 | -0.0000824431 | -179.837 | -0.012700000294395381,1.6337334414560797e-10,-0.012700000002607008 | 0.012700003763475718,7.670866303416739,0.016120937914577065
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.544Z | Extended Element | 5333566.120789323,2184680.9053267194,361.01773391641086 | -89.1454 | 0.0000176808 | -179.837 | -0.012700000428379783,-7.6721341181819313e-11,-0.012700000003158131 | 0.012700000541120457,7.6708666283796321,0.016235388983743732
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.569Z | Extended Element | 5333566.0188418655,2184680.6116729435,361.01158986013144 | -89.1454 | -0.0000708172 | -179.837 | -0.012699999989711446,4.3095551825980532e-10,-0.012700000003283739 | 0.012700005028672051,7.6708669540878773,0.016349840048479444
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.596Z | Extended Element | 5333565.9168944051,2184680.3180191647,361.00544580341085 | -89.1454 | -0.0000599781 | -179.837 | -0.012699999824967681,3.9544423007568507e-10,-0.012700000006116778 | 0.012700003761094019,7.6708672811678777,0.0164642911239243
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.622Z | Extended Element | 5333565.8149469448,2184680.0243653869,360.99930174589809 | -89.1454 | -0.0000395223 | -179.837 | -0.012700004666195261,3.8203925554341687e-10,-0.012700000002969442 | 0.01270000010757818,7.6708587372212937,0.016578808514805216
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.646Z | Extended Element | 5333565.7279591672,2184679.7738021086,360.99415135952989 | -89.1454 | 0.0000441871 | -179.837 | -0.012700001110491363,9.8186152228301074e-12,-0.012700000007073647 | 0.012700000090909123,7.6708678806447157,0.016676398802260694
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.671Z | Extended Element | 5333565.6570391953,2184679.5695212204,360.98978513640151 | -89.1454 | -0.0000838315 | -179.837 | -0.012700000063613258,1.27765131713116e-10,-0.01269999999931788 | 0.012700004943176911,7.6708681077305831,0.016756016939897863
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.698Z | Extended Element | 5333557.9023089539,2184679.210932801,360.95873212828837 | -89.1454 | 180 | -0.224457 | -0.012700005652472934,2.3323855090120094e-10,-0.012700000004315268 | 0.0126999998730417,7.6708684025253531,0.016806557099056516
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.726Z | Extended Element | 5333557.8003614936,2184678.9172790241,360.9524736199678 | -89.1454 | 180 | -0.224457 | -0.012700011362889146,6.982853872537487e-10,-0.012700000002060662 | 0.012700000120115901,7.6708688521706359,0.016692106448287506
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.751Z | Extended Element | 5333557.6984140333,2184678.6236252463,360.94621511161171 | -89.1454 | -180 | -0.224457 | -0.012700000673440221,7.7597191320267819e-10,-0.0127000000029095 | 0.012700000286933156,7.6708693023819485,0.016577655731266901
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.778Z | Extended Element | 5333557.5964665757,2184678.3299714685,360.9399566032597 | -89.1454 | -180 | -0.224457 | -0.012700000288301391,-1.3897128128505494e-10,-0.012700000001549659 | 0.012700001624142634,7.670869747786317,0.016463205124618293
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.802Z | Extended Element | 5333557.4945191182,2184678.0363176921,360.93369809494163 | -89.1454 | 180 | -0.224457 | -0.012700003670250247,4.5286782931472802e-10,-0.012700000004966735 | 0.01270000017616661,7.6708701947000746,0.016348754466045456
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.829Z | Extended Element | 5333557.392571657,2184677.7426639129,360.92743958672634 | -89.1454 | -180 | -0.224457 | -0.012700000283327871,8.5286539959259086e-10,-0.01270000000504546 | 0.01270000115233284,7.6708706442776,0.01623430379361367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.854Z | Extended Element | 5333557.2906241966,2184677.4490101347,360.92118107842737 | -89.1454 | -180 | -0.224457 | -0.012700000154758254,-1.0976418175821012e-10,-0.012700000001127532 | 0.012700003902004367,7.6708561541785549,0.016119795190665101
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.880Z | Extended Element | 5333557.203636419,2184677.1984468577,360.91585922727381 | -89.1454 | -180 | -0.224559 | -0.012700001044113346,2.5327584469261609e-10,-0.012700000000511592 | 0.012699999909560979,7.6708715036518615,0.01603313607027447
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.907Z | Extended Element | 5333564.8026751624,2184677.1085748887,360.93828754194647 | -89.1454 | -0.000108436 | -179.825 | -0.01269999981804327,-1.1180625217085633e-10,-0.012700000001182078 | 0.012700005430866933,7.67087176862898,0.016074546842287804
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.933Z | Extended Element | 5333592.5627550147,2184689.9700674913,360.96563147132457 | -89.1454 | -180 | 0.0592707 | -0.012700000229232162,5.3833534843341059e-10,-0.012700000001045009 | 0.012700000491940318,7.6708337197213448,0.016553594301477938
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.958Z | Extended Element | 5333592.4918350428,2184689.7657866022,360.96978135743598 | -89.1454 | -180 | 0.0592707 | -0.012700000424055667,6.4522876616241792e-10,-0.012700000004039766 | 0.012700000063035545,7.6708336387685003,0.01647397588252204
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:49.982Z | Extended Element | 5333592.4048472652,2184689.5152233243,360.97485592087389 | -89.1454 | -180 | 0.0592707 | -0.012700000030477877,2.1216693102826667e-10,-0.012700000002506959 | 0.012700003550361301,7.6708335353384962,0.016376318923047584
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.012Z | Extended Element | 5333592.3028998058,2184689.221569547,360.98080259606684 | -89.1454 | -180 | 0.0592707 | -0.012700000674337566,7.6620025026858914e-10,-0.012700000005176714 | 0.012700007442403115,7.6708334176390665,0.016261867453795577
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.039Z | Extended Element | 5333592.2009523455,2184688.9279157692,360.9867545934336 | -89.1454 | -180 | 0.0592707 | -0.012699999841523977,5.1029119808118228e-10,-0.01270000000011369 | 0.012700004450010459,7.6708333000767253,0.016147415977925756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.066Z | Extended Element | 5333592.099004888,2184688.6342619914,360.99270599821773 | -89.1454 | -180 | 0.0592485 | -0.012700000796190424,-6.520167111766086e-10,-0.012700000001642177 | 0.012699999923134375,7.670833180815352,0.016035345966882109
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.097Z | Extended Element | 5333599.6670161411,2184688.4550171322,360.98749447037852 | -89.1454 | 0.0000460738 | 179.891 | -0.012700002200382435,-7.3075312899673742e-10,-0.012700000002918446 | 0.012699999949516363,7.6708329679211795,0.016098645646534557
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.124Z | Extended Element | 5333599.5650686836,2184688.1613633549,360.99353585696616 | -89.1454 | 0.0000632518 | 179.891 | -0.012700002568726927,-1.5138371016075126e-10,-0.012700000003080008 | 0.012700000297366886,7.6708327520167741,0.016213096958224666
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.149Z | Extended Element | 5333599.4631212214,2184687.8677095771,360.99957941321696 | -89.1454 | -0.000113277 | 179.891 | -0.012700000072960245,9.1323171061845066e-11,-0.012699999999147348 | 0.01270000517224852,7.6708325338657231,0.016327548304621672
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.178Z | Extended Element | 5333599.3783496954,2184687.6235300777,361.00460645434259 | -89.1454 | 0.000014751 | 179.891 | -0.012700001506560536,6.2858564055830371e-10,-0.012700000001578431 | 0.012700000395913517,7.6708323541586276,0.01642271705851164
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.205Z | Extended Element | 5333599.3074297234,2184687.4192491882,361.00880897393529 | -89.1454 | 0.000129949 | 179.891 | -0.012700005650019138,-2.0670465346646605e-10,-0.012700000000795807 | 0.012700000072026728,7.6708322045500639,0.016502335381025961
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.232Z | Extended Element | 5333599.220441943,2184687.1686859103,361.01396570356729 | -89.1454 | -0.000117445 | 179.891 | -0.012700000166796878,-4.4371439861728672e-10,-0.012700000000341069 | 0.012700006270504766,7.6708320154855452,0.016599992227527154
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.261Z | Extended Element | 5333599.1184944846,2184686.8750321325,361.02003094326079 | -89.1454 | 0.000127124 | 179.891 | -0.01270000625511095,6.8590063943684281e-11,-0.012700000002478532 | 0.012700000190037707,7.6708318023782072,0.016714443547419688
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.288Z | Extended Element | 5333591.3465883108,2184686.4669694365,361.03646536740251 | -89.1454 | 180 | 0.0469347 | -0.012700003492293296,-2.8914488112974567e-10,-0.012700000003618064 | 0.012700000092926475,7.670831584583186,0.016828887188350936
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.312Z | Extended Element | 5333591.2446408542,2184686.1733156587,361.04239447082279 | -89.1454 | 180 | 0.0469347 | -0.01270000625511095,6.8590063943684281e-11,-0.012700000002478532 | 0.012700000190037707,7.6708318023782072,0.016714443547419688
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.336Z | Extended Element | 5333591.1426933948,2184685.8796618809,361.04832357386971 | -89.1454 | 180 | 0.0469347 | -0.012700000166796878,-4.4371439861728672e-10,-0.012700000000341069 | 0.012700006270504766,7.6708320154855452,0.016599992227527154
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.366Z | Extended Element | 5333591.0407459354,2184685.5860081036,361.05425267728236 | -89.1454 | 180 | 0.0469347 | -0.012700005170441815,3.3023836199443614e-10,-0.012700000002736843 | 0.012700000319474982,7.6708313029137987,0.016485532701086016
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.394Z | Extended Element | 5333590.9387984769,2184685.2923543258,361.06018178015677 | -89.1454 | -180 | 0.0469347 | -0.012700000705233413,-2.7027824426249234e-10,-0.012700000000000001 | 0.012700000248440911,7.6708312078968701,0.016371081209869125
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.421Z | Extended Element | 5333590.8540269481,2184685.048174826,361.06511195813442 | -89.1454 | 180 | 0.0469347 | -0.012700011686584054,1.5082543220475164e-10,-0.012700000001613452 | 0.012699999993744351,7.6708311310703516,0.016275912298266422
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.448Z | Extended Element | 5333590.7831069734,2184684.8438939373,361.06924135312426 | -89.1454 | 180 | 0.0469347 | -0.012700005695088102,2.3133710570450606e-10,-0.012700000002656812 | 0.012700000035988354,7.6708310682105649,0.016196293875587776
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.475Z | Extended Element | 5333590.6961191967,2184684.5933306594,361.0742613836498 | -89.1454 | 180 | 0.0469347 | -0.012700002200382435,-7.3075312899673742e-10,-0.012700000002918446 | 0.012699999949516363,7.6708329679211795,0.016098645646534557
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.500Z | Extended Element | 5333590.5941717364,2184684.2996768807,361.07921056401705 | -89.1454 | 180 | 0.0465575 | -0.012700002807657264,-9.3059054319638327e-11,-0.012700000003567935 | 0.012700000305041214,7.6708282160301371,0.016024331522183213
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.526Z | Extended Element | 5333598.1621829933,2184684.1204320234,361.0727689621562 | -89.1454 | -0.000111865 | 179.904 | -0.012699999841523977,5.1029119808118228e-10,-0.01270000000011369 | 0.012700004450010459,7.6708333000767253,0.016147415977925756
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.550Z | Extended Element | 5333598.060235532,2184683.8267782447,361.07390394181442 | -89.1454 | -0.0000134436 | 179.904 | -0.012700000674337566,7.6620025026858914e-10,-0.012700000005176714 | 0.012700007442403115,7.6708334176390665,0.016261867453795577
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.577Z | Extended Element | 5333597.9593961956,2184683.5363163496,361.07312223220362 | -89.1454 | 0.000100204 | 179.904 | -0.012700006705296854,-1.8752784104502875e-10,-0.012700000005634449 | 0.012700000217566077,7.670830281020562,0.016375085359286189
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.603Z | Extended Element | 5333597.8574487381,2184683.2426625728,361.07035669161343 | -89.1454 | 0.0000289367 | 179.904 | -0.012700002071565835,-1.3494388763219259e-10,-0.012700000003030299 | 0.012700000318931527,7.6708300903359508,0.016489536721046985
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.630Z | Extended Element | 5333597.7555012796,2184682.9490087936,361.06567105236223 | -89.1454 | 0.0000464548 | 179.904 | -0.012700002941396438,-3.3596831854980803e-10,-0.012700000002811747 | 0.012700000179399058,7.6708298994003945,0.016603988094847588
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.657Z | Extended Element | 5333597.6685134992,2184682.6984455171,361.06088778111985 | -89.1454 | 0.0000755037 | 179.904 | -0.012700006215712571,2.2608270804570379e-10,-0.012699999999374727 | 0.012699999983170496,7.6708297330664159,0.016701644977368313
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.683Z | Extended Element | 5333597.5975935282,2184682.494164627,361.056966408449 | -89.1454 | 0.00000341126 | 179.904 | -0.012700000530991594,-2.9636473428954848e-10,-0.012700000004493539 | 0.012700000669553145,7.6708295999868232,0.01678126331430153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.708Z | Extended Element | 5333589.842863285,2184682.1355762095,361.06093896838922 | -89.1454 | -180 | 0.0345986 | -0.012700000530991594,-2.9636473428954848e-10,-0.012700000004493539 | 0.012700000669553145,7.6708295999868232,0.01678126331430153
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.735Z | Extended Element | 5333589.7409158256,2184681.8419224308,361.05516115654257 | -89.1454 | -180 | 0.0345986 | -0.012700000220692268,-2.9066289271320184e-10,-0.012700000000693042 | 0.012700005505162169,7.6708294226055047,0.016666900567602737
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.763Z | Extended Element | 5333589.6389683671,2184681.5482686535,361.04938334500724 | -89.1454 | 180 | 0.0345986 | -0.012700000097111962,1.5717832589242418e-10,-0.012700000000000012 | 0.012700001094980923,7.6708293515277965,0.016552449052341749
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.785Z | Extended Element | 5333589.5370209077,2184681.2546148761,361.043605533218 | -89.1454 | -180 | 0.0345986 | -0.012700000085306478,1.1707935619010269e-10,-0.012700000002347589 | 0.012700005881196227,7.6708292847331041,0.016437997542563424
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.812Z | Extended Element | 5333589.4350734465,2184680.9609610974,361.03782772184491 | -89.1454 | 180 | 0.0345986 | -0.012700003025718323,2.0348559700768564e-10,-0.012700000002295498 | 0.012700000078354822,7.6708292161547451,0.016323546032269876
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.839Z | Extended Element | 5333589.333125988,2184680.6673073201,361.03204991002872 | -89.1454 | -180 | 0.0345986 | -0.012700000009278315,-3.3515362471967464e-10,-0.012700000002334967 | 0.012700002856015021,7.6708291459976703,0.016209094520557247
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.866Z | Extended Element | 5333589.2311785296,2184680.3736535427,361.02627209741581 | -89.1454 | -180 | 0.0345986 | -0.012700000011561508,-3.7023819616814899e-10,-0.012700000002231098 | 0.012700003329986338,7.67082907539067,0.016094643007179527
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.893Z | Extended Element | 5333589.144190751,2184680.1230902639,361.02142642578582 | -89.1454 | -180 | 0.0343126 | -0.012700000241340294,-9.4951743174493101e-11,-0.012700000001827073 | 0.012700007391784163,7.6708263524894313,0.01602749024558682
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.920Z | Extended Element | 5333596.7432294926,2184680.0332182944,361.00946052317443 | -89.1454 | -0.0000382222 | 179.916 | -0.012699999972261261,-4.922007262581006e-11,-0.012700000000170533 | 0.012700003127180301,7.6708288802121114,0.016099794699753308
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.948Z | Extended Element | 5333596.6584579656,2184679.7890387941,361.00473228213855 | -89.1454 | -0.0000932018 | 179.916 | -0.012700000372123755,-6.4338612219400793e-10,-0.012700000000170535 | 0.012700004157829268,7.6708287394280292,0.016194963536167898
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:50.976Z | Extended Element | 5333596.5565105062,2184679.4953850168,360.99904603147377 | -89.1454 | -0.0000825057 | 179.916 | -0.012700000165280736,-7.8777495640632192e-10,-0.012699999998976825 | 0.012700004126253706,7.6708285723906808,0.01630941494854176
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.001Z | Extended Element | 5333596.4545630477,2184679.2017312394,360.99335978078062 | -89.1454 | -0.0000666256 | 179.916 | -0.012700000409219449,3.3408658374262965e-10,-0.012700000005488453 | 0.012700004371086569,7.6708284066246168,0.016423866351511732
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.029Z | Extended Element | 5333596.3526155865,2184678.9080774616,360.9876735300852 | -89.1454 | -0.000064291 | 179.916 | -0.012700000139308869,-5.6573529349024151e-10,-0.012700000002181652 | 0.012700004157731109,7.6708282369222012,0.016538317779012837
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.056Z | Extended Element | 5333596.2506681271,2184678.6144236829,360.98198727943509 | -89.1454 | 0.000172628 | 179.916 | -0.012700008030812171,7.2910306355672431e-10,-0.012700000002160794 | 0.01269999985005881,7.6708280694170448,0.01665276918154061
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.083Z | Extended Element | 5333596.1487206686,2184678.320769906,360.97630102888428 | -89.1454 | -0.0000217581 | 179.916 | -0.0126999997927936,1.1595138922980372e-11,-0.012699999999261035 | 0.012700002824769329,7.6708279027570203,0.016767220588321745
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.109Z | Extended Element | 5333588.3768144958,2184677.9127072101,360.97767143496674 | -89.1454 | 180 | 0.0222626 | -0.012700012687716507,4.8073080380081912e-10,-0.012699999999829469 | 0.012700000190691224,7.6708277925998898,0.016776114057567546
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.133Z | Extended Element | 5333588.2898267191,2184677.6621439322,360.97274295243284 | -89.1454 | 180 | 0.0222626 | -0.012700007636022298,-1.8414551626449726e-10,-0.012700000006645394 | 0.012700000485318969,7.6708277528408839,0.016678457056649779
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.160Z | Extended Element | 5333588.2189067462,2184677.4578630421,360.96868665186906 | -89.1454 | 180 | 0.0222626 | -0.012700012862342853,3.8225722738797047e-10,-0.012700000002740363 | 0.012700000257656694,7.6708277209788935,0.016598838603751973
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.168Z | Line String | 5333557.1327164471,2184676.9941659686,360.87033341527535 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.026819012753719562
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.177Z | Line String | 5333557.203636419,2184677.1984468573,360.87456311532742 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.026731198088896235
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.184Z | Line String | 5333557.239096405,2184677.3005873021,360.87677215215132 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.026688648300932982
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.194Z | Line String | 5333557.3415979268,2184677.595837024,360.88303525007643 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.026573574749534146
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.202Z | Line String | 5333557.4435897106,2184677.8896184778,360.88929647944724 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.026459073455498583
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.212Z | Line String | 5333557.5455814954,2184678.1833999311,360.89555770893338 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.026344572161349333
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.222Z | Line String | 5333557.6475732801,2184678.4771813848,360.90181893836296 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.026230070867200084
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.229Z | Line String | 5333557.749565064,2184678.7709628385,360.90808598069509 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.026115569573164521
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.239Z | Line String | 5333557.8515568487,2184679.0647442923,360.91437688574928 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.026001068280038453
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.247Z | Line String | 5333557.9518421208,2184679.3536102367,360.92049786442385 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.025888482805839885
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.257Z | Line String | 5333557.9873021077,2184679.4557506805,360.92301882848324 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.025848673576433612
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.264Z | Line String | 5333558.0582220787,2184679.6600315697,360.92702848152578 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.025769055121770634
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.273Z | Line String | 5333558.0936820637,2184679.7621720135,360.92920535397741 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.025729245893444386
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.282Z | Line String | 5333558.1961835865,2184680.057421736,360.93549787588796 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.025614172341988706
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.301Z | Line String | 5333558.2981753703,2184680.3512031897,360.94196705158191 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.025499671048009986
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.310Z | Line String | 5333558.4001671541,2184680.6449846434,360.94802033474969 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.025385169753803893
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.319Z | Line String | 5333558.5021589398,2184680.9387660963,360.95428156408718 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.025270668459768331
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.329Z | Line String | 5333558.6041507237,2184681.23254755,360.96054279356434 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.025156167165675924
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.336Z | Line String | 5333558.7061425075,2184681.5263290037,360.96679753013581 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.025030729105480987
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.344Z | Line String | 5333558.8064277805,2184681.8151949481,360.97293148006861 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024918143630770828
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.351Z | Line String | 5333558.8418877665,2184681.9173353924,360.97510039058506 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024878334401364555
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.360Z | Line String | 5333558.9128077384,2184682.1216162811,360.97943821180093 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.024798715946303673
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.368Z | Line String | 5333558.9482677234,2184682.2237567259,360.98160712229895 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.024758906717750051
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.377Z | Line String | 5333559.0507692453,2184682.5190064479,360.9875878873483 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024643833165953311
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.386Z | Line String | 5333559.15276103,2184682.8127879011,360.99186603487846 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891912207007,0.024529331871349314
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.396Z | Line String | 5333559.2547528148,2184683.1065693549,360.99443389180095 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.024414830576859003
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.406Z | Line String | 5333559.3567445986,2184683.4003508086,360.9948428207054 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.024300329282255007
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.414Z | Line String | 5333559.4587363834,2184683.6941322624,360.99305441119543 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.024185827987707853
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.425Z | Line String | 5333559.5607281672,2184683.9879137157,360.98947510732665 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.024071326694127038
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.433Z | Line String | 5333559.6610134402,2184684.27677966,360.98450642945767 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.023958741219530566
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.444Z | Line String | 5333559.6964734262,2184684.3789201044,360.98257506503973 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.023918931990010606
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.451Z | Line String | 5333559.7673933981,2184684.583200993,360.97871316136656 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891865640879,0.023839313534949724
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.461Z | Line String | 5333559.8028533831,2184684.6853414373,360.97687433940342 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.023799504306452945
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.469Z | Line String | 5333559.9053549049,2184684.9805911598,360.97136660288191 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.023684430754599362
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.479Z | Line String | 5333560.0073466888,2184685.2743726131,360.96588587271799 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.023569929460052208
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.487Z | Line String | 5333560.1093384745,2184685.5681540668,360.96057908780671 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.1144089181907475,0.023451063177503784
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.497Z | Line String | 5333560.2113302583,2184685.8619355205,360.95499863444678 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.023329990104741682
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.506Z | Line String | 5333560.3133220421,2184686.1557169738,360.94954010152605 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.023215488810762963
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.515Z | Line String | 5333560.4153138278,2184686.4494984276,360.94398452064956 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.1144089181907475,0.023100987517693738
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.525Z | Line String | 5333560.515599099,2184686.7383643715,360.93874074282866 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.022988402043608858
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.533Z | Line String | 5333560.5510590859,2184686.8405048158,360.93672852676366 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891865640879,0.022948592814259428
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.544Z | Line String | 5333560.6219790569,2184687.0447857045,360.93289324800423 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.022868974359653294
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.553Z | Line String | 5333560.6574390437,2184687.1469261488,360.93108646435138 | 0 | 0 | 0 | 0,0,0 | 7.6699587125331163,0.11440891865640879,0.022829165131383888
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.563Z | Line String | 5333560.7599405646,2184687.4421758712,360.92555971989378 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.022714091579928208
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.573Z | Line String | 5333560.8619323494,2184687.735957325,360.92008864193986 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.022599590286006332
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.581Z | Line String | 5333560.9639241332,2184688.0297387782,360.91460791689565 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891865640879,0.02248508899197077
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.590Z | Line String | 5333561.065915918,2184688.3235202315,360.9091510004917 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.022370587697935207
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.599Z | Line String | 5333561.1679077018,2184688.6173016853,360.90360148788403 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.11440891865640879,0.022256086403956488
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.610Z | Line String | 5333561.2698994866,2184688.911083139,360.89826695442775 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.022141585110887263
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.619Z | Line String | 5333561.3701847587,2184689.1999490834,360.89279348251404 | 0 | 0 | 0 | 0,0,0 | 7.6699587143957615,0.1144089181907475,0.022028999636859226
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.627Z | Line String | 5333561.4056447446,2184689.3020895272,360.89093802990601 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.11440891912207007,0.021989190407566639
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.636Z | Line String | 5333561.4765647165,2184689.5063704168,360.88702948042578 | 0 | 0 | 0 | 0,0,0 | 7.6699587134644389,0.1144089181907475,0.021909571950686768
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.645Z | Line String | 5333588.2189067453,2184677.4578630426,360.92755153795105 | 0 | 0 | 0 | 0,0,-0.0068793812499734486 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.655Z | Line String | 5333588.2898267172,2184677.6621439317,360.93144684048025 | 0 | 0 | 0 | 0,0,-0.0069589997078765009 | 7.6699587125331163,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.664Z | Line String | 5333588.3252867032,2184677.7642843756,360.93349389983086 | 0 | 0 | 0 | 0,0,-0.0069988089363164363 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.674Z | Line String | 5333588.4277882241,2184678.059534098,360.93929670354959 | 0 | 0 | 0 | 0,0,-0.00711388248799949 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.682Z | Line String | 5333588.5297800088,2184678.3533155518,360.94509992774334 | 0 | 0 | 0 | 0,0,-0.0072283837823761132 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.692Z | Line String | 5333588.6317717936,2184678.6470970055,360.95090315205238 | 0 | 0 | 0 | 0,0,-0.0073428850768095799 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.700Z | Line String | 5333588.7337635774,2184678.9408784588,360.95670637630474 | 0 | 0 | 0 | 0,0,-0.0074573863711862032 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.709Z | Line String | 5333588.8357553612,2184679.2346599121,360.96251541345981 | 0 | 0 | 0 | 0,0,-0.0075718876655628264 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.718Z | Line String | 5333588.9377471469,2184679.5284413658,360.96834831334081 | 0 | 0 | 0 | 0,0,-0.0076863889589162682 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.728Z | Line String | 5333589.0380324181,2184679.8173073102,360.97401895011791 | 0 | 0 | 0 | 0,0,-0.0077989744333990529 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.738Z | Line String | 5333589.073492405,2184679.9194477545,360.97638067725961 | 0 | 0 | 0 | 0,0,-0.0078387836628621699 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.746Z | Line String | 5333589.144412376,2184680.1237286432,360.98007185648288 | 0 | 0 | 0 | 0,0,-0.0079216009344236227 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.753Z | Line String | 5333589.1798723629,2184680.2258690875,360.98208926812538 | 0 | 0 | 0 | 0,0,-0.0079691481129202657 | 7.6699587125331163,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.763Z | Line String | 5333589.2823738838,2184680.5211188095,360.98789848111915 | 0 | 0 | 0 | 0,0,-0.0080842216643759457 | 7.6699587143957615,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.770Z | Line String | 5333589.3843656685,2184680.8149002632,360.9938867513772 | 0 | 0 | 0 | 0,0,-0.0081987229585820387 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.781Z | Line String | 5333589.4863574523,2184681.108681717,360.99945912910891 | 0 | 0 | 0 | 0,0,-0.0083132242527312883 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.790Z | Line String | 5333589.5883492371,2184681.4024631707,361.00523945301046 | 0 | 0 | 0 | 0,0,-0.0084277255469373813 | 7.6699587143957615,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.800Z | Line String | 5333589.6903410219,2184681.6962446244,361.01101977705162 | 0 | 0 | 0 | 0,0,-0.0085422268410297875 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.809Z | Line String | 5333589.7923328057,2184681.9900260773,361.01680010109436 | 0 | 0 | 0 | 0,0,-0.0086567281342695424 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.818Z | Line String | 5333589.8926180787,2184682.2788920216,361.02248370912946 | 0 | 0 | 0 | 0,0,-0.0087693136085817969 | 7.6699587134644389,0.11440891912207007,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.828Z | Line String | 5333589.9280780638,2184682.3810324664,361.02449338272817 | 0 | 0 | 0 | 0,0,-0.008809122837931227 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.840Z | Line String | 5333589.9989980357,2184682.5853133551,361.02851273012453 | 0 | 0 | 0 | 0,0,-0.0088887412926510478 | 7.6699587143957615,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.850Z | Line String | 5333590.0344580216,2184682.6874537994,361.0305224037088 | 0 | 0 | 0 | 0,0,-0.0089285505210909832 | 7.6699587134644389,0.11440891865640879,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.861Z | Line String | 5333590.1369595435,2184682.9827035218,361.03604287455153 | 0 | 0 | 0 | 0,0,-0.0090436240724898198 | 7.6699587134644389,0.1144089181907475,0
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:51.870Z | Line String | 5333590.2389513282,2184683.2764849751,361.03986301690435 | 0 | 0 | 0 | 0,0,-0.0091581253666959128 | 7.6699587134644389,0.11440891865640879,0
