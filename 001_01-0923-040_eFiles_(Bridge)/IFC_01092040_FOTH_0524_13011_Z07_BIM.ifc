Properties of the parts of a building model (IFC4X3_ADD2), part 21 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.637Z | Line String | 5333608.5211673426,2184683.5460162209,361.0517489998004 | 0 | 0 | 0 | -59.982853369787335,-0.89473406970500946,-0.057584089986733034 | 0,0,0.03708252808536372
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.646Z | Line String | 5333608.4191755587,2184683.2522347677,361.04812629879683 | 0 | 0 | 0 | -59.982853369787335,-0.89473407017067075,-0.058391114356879825 | 0,0,0.036743497142936121
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.654Z | Line String | 5333608.3177821608,2184682.960176934,361.04296718663477 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.059193403901474539 | 0,0,0.03640645529833364
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.663Z | Line String | 5333608.246862188,2184682.7558960454,361.03911609650646 | 0 | 0 | 0 | -59.982853366993368,-0.89473407063633204,-0.059754568172763811 | 0,0,0.03617071018442175
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.671Z | Line String | 5333608.1759422161,2184682.5516151558,361.03541773356318 | 0 | 0 | 0 | -59.982853366993368,-0.89473406970500946,-0.06031573245763866 | 0,0,0.035934965064654989
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.681Z | Line String | 5333608.0745488191,2184682.2595573221,361.02979816827275 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.06111802200166494 | 0,0,0.035597923222724148
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.689Z | Line String | 5333607.9725570353,2184681.9657758689,361.02430509546161 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.061925046377552917 | 0,0,0.03525889227847756
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.699Z | Line String | 5333607.8705652505,2184681.6719944151,361.01878712692223 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.062732070742299584 | 0,0,0.034919861337243674
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.708Z | Line String | 5333607.7685734658,2184681.3782129618,361.01341174351228 | 0 | 0 | 0 | -59.982853366993368,-0.89473407063633204,-0.063539095118130717 | 0,0,0.03458083039305393
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.717Z | Line String | 5333607.6665816819,2184681.0844315081,361.00777608522645 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.064346119482195263 | 0,0,0.034241799451706356
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.725Z | Line String | 5333607.5645898981,2184680.7906500543,361.00227056466912 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.065153143850864126 | 0,0,0.03390276851047247
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.735Z | Line String | 5333607.4631965011,2184680.4985922212,360.99679698302214 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.065955071931455223 | 0,0,0.033566088131863125
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.744Z | Line String | 5333607.3922765283,2184680.2943113321,360.99295279605451 | 0 | 0 | 0 | -59.98285336792469,-0.89473407017067075,-0.066500312511607262 | 0,0,0.033346266709031624
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.753Z | Line String | 5333607.3213565564,2184680.0900304429,360.98910860926577 | 0 | 0 | 0 | -59.98285336792469,-0.89473407063633204,-0.067045553105344879 | 0,0,0.033126445280799999
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.762Z | Line String | 5333607.2199631594,2184679.7979726093,360.98361262368837 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.067825076746430568 | 0,0,0.032812169340900255
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.771Z | Line String | 5333607.1179713756,2184679.5041911555,360.97808420241108 | 0 | 0 | 0 | -59.982853368856013,-0.89473406970500946,-0.068609200863477326 | 0,0,0.032496038655096982
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.780Z | Line String | 5333607.0159795899,2184679.2104097023,360.97255578150668 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.069393324973759718 | 0,0,0.032179907971965349
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.787Z | Line String | 5333606.9139878061,2184678.916628249,360.96702736016044 | 0 | 0 | 0 | -59.982853368856013,-0.89473407063633204,-0.070177449086656907 | 0,0,0.031863777286162076
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.798Z | Line String | 5333606.8119960222,2184678.6228467952,360.96161915481701 | 0 | 0 | 0 | -59.982853368856013,-0.89473407017067075,-0.07096157319597296 | 0,0,0.031547646603030444
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.805Z | Line String | 5333606.7100042375,2184678.3290653415,360.95597051794209 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.071745697305857448 | 0,0,0.031231515919898811
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.816Z | Line String | 5333606.6086108396,2184678.0370075079,360.95048021634676 | 0 | 0 | 0 | -59.982853366993368,-0.89473406970500946,-0.07252522094717051 | 0,0,0.030917239979942224
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.823Z | Line String | 5333606.5376908677,2184677.8327266192,360.94665492710908 | 0 | 0 | 0 | -59.982853366993368,-0.89473407017067075,-0.073070461526867803 | 0,0,0.030697418557110723
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.834Z | Line String | 5333606.4667708967,2184677.6284457305,360.94278615909542 | 0 | 0 | 0 | -59.982853368856013,-0.89473407063633204,-0.073615702108611458 | 0,0,0.030477597134677126
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.843Z | Line String | 5333606.3958509248,2184677.4241648414,360.9389600267566 | 0 | 0 | 0 | -59.98285336792469,-0.89473406970500946,-0.074160942685523423 | 0,0,0.030257775712300372
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.851Z | Line String | 5333606.3453591121,2184676.9153541611,360.93555857626461 | 0 | 0 | 0 | -59.996129900217056,-0.89493210939690471,-0.074647507245742872 | 0,0,0.030085164506431283
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:56.861Z | Line String | 5333606.3419495728,2184677.1439291909,360.93555857641059 | 0 | 0 | 0 | -59.996129900217056,-0.89493210939690471,-0.074647507244492317 | 0,0,0.030085164507113404
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.060Z | Complex Chain | 5333550.6971480893,2184690.0272043967,361.07962093199973 | 0 | 0 | 0 | 0,-0.087840463500469923,0 | 60.646005105227232,0.90410180622711778,0.084684050374278286
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.093Z | Complex Chain | 5333550.6961584697,2184690.090754488,361.35902184202121 | 0 | 0 | 0 | 0,-0.087429866194725037,0 | 60.646087499335408,0.90410924330353737,0.084683697981574824
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.133Z | Complex Chain | 5333550.695813599,2184690.113874638,361.52835890247769 | 0 | 0 | 0 | 0,-0.087429867126047611,0 | 60.646087495610118,0.90410929871723056,0.084683698034041299
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.168Z | Extended Element | 5333550.6958136,2184690.1138746375,361.52835890248423 | 0.989968 | 90.2521 | -95.9265 | -0.027705884498080723,-7.209542163558629e-10,-0.0091131348629907346 | 0.0091131480338251091,10.854813975741781,1.0056614571942559
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.183Z | Extended Element | 5333560.6392286718,2184690.159666718,361.56949857396728 | -89.1454 | -180 | -0.18745 | -0.0093038691680189488,-2.9400970549609442e-10,-0.0079375000019326781 | 0.0093039942527530523,10.100279790484677,0.02974256544562268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.197Z | Extended Element | 5333570.5863452675,2184690.3080428569,361.59731990413383 | -89.1454 | 180 | -0.113434 | -0.0093038294906130758,-4.8603931992203614e-10,-0.0079374999990905123 | 0.0093038604839282141,10.820049288210186,0.03056246435930951
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.210Z | Extended Element | 5333580.5334907752,2184690.456419426,361.61143866853632 | -89.1454 | 180 | -0.0270816 | -0.0093039452112990001,-8.0431618205278167e-10,-0.0079375000006193797 | 0.0093038726672590374,10.015805020453358,0.029851714333242744
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.223Z | Extended Element | 5333590.4806462443,2184690.6047961437,361.61130621368363 | -89.1454 | 180 | 0.0469347 | -0.0093038224522721015,-5.5374162667441104e-10,-0.007937500000738968 | 0.0093038428125547749,10.735576481200328,0.030689788266865973
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.237Z | Extended Element | 5333600.4277921002,2184690.7531727185,361.59745290519794 | -89.1454 | -180 | 0.133287 | -0.0091129622010002846,-1.5190292146723409e-10,-0.0079375000004777221 | 0.10989699583746493,10.917685483167553,0.014131414088362318
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.287Z | Extended Element | 5333550.6961584697,2184690.0907544876,361.3590218420253 | 0.989977 | 90.2521 | -95.9265 | -0.027705884498080723,-7.209542163558629e-10,-0.0091131348629907346 | 0.0091131480338251091,10.854813975741781,1.0056614571942559
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.298Z | Extended Element | 5333560.6395735433,2184690.1365465694,361.40016151344707 | -89.1454 | -180 | -0.18745 | -0.0093038691680189488,-2.9400970549609442e-10,-0.0079375000019326781 | 0.0093039942527530523,10.100279790484677,0.02974256544562268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.308Z | Extended Element | 5333570.5866901372,2184690.2849227078,361.42798284361919 | -89.1454 | -180 | -0.113434 | -0.0093038294906130758,-4.8603931992203614e-10,-0.0079374999990905123 | 0.0093038604839282141,10.820049288210186,0.03056246435930951
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.317Z | Extended Element | 5333580.5338356467,2184690.4332992774,361.44210160802783 | -89.1454 | 180 | -0.0270816 | -0.0093039452112990001,-8.0431618205278167e-10,-0.0079375000006193797 | 0.0093038726672590374,10.015805020453358,0.029851714333242744
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.325Z | Extended Element | 5333590.4809911139,2184690.5816759947,361.44196915317428 | -89.1454 | 180 | 0.0469347 | -0.0093038224522721015,-5.5374162667441104e-10,-0.007937500000738968 | 0.0093038428125547749,10.735576481200328,0.030689788266865973
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.335Z | Extended Element | 5333600.4281369718,2184690.7300525699,361.42811584468933 | -89.1454 | 180 | 0.133287 | -0.0091129622010002846,-1.5190292146723409e-10,-0.0079375000004777221 | 0.10989699583746493,10.917685483167553,0.014131414088362318
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.391Z | Extended Element | 5333550.6971480884,2184690.0272043967,361.07962093199046 | 0.921657 | 90.2521 | -95.8814 | -0.027706107951518288,-1.3289014306984404e-11,-0.0091135678035159616 | 0.0091135662663971353,10.85441165507844,1.0096515630510472
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.401Z | Extended Element | 5333560.6405276135,2184690.0725858826,361.12076095581517 | -89.1454 | -180 | -0.18745 | -0.0093038691680189488,-2.9400970549609442e-10,-0.0079375000019326781 | 0.0093039942527530523,10.100279790484677,0.02974256544562268
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.411Z | Extended Element | 5333570.5876442054,2184690.2209620192,361.14858228598877 | -89.1454 | -180 | -0.113434 | -0.0093038294906130758,-4.8603931992203614e-10,-0.0079374999990905123 | 0.0093038604839282141,10.820049288210186,0.03056246435930951
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.420Z | Extended Element | 5333580.5347897122,2184690.3693385897,361.1627010503974 | -89.1454 | 180 | -0.0270816 | -0.0093039452112990001,-8.0431618205278167e-10,-0.0079375000006193797 | 0.0093038726672590374,10.015805020453358,0.029851714333242744
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.431Z | Extended Element | 5333590.4819451831,2184690.5177153065,361.16256859554801 | -89.1454 | -180 | 0.0469347 | -0.0093038224522721015,-5.5374162667441104e-10,-0.007937500000738968 | 0.0093038428125547749,10.735576481200328,0.030689788266865973
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.442Z | Extended Element | 5333600.429091041,2184690.6660918817,361.14871528706146 | -89.1454 | 180 | 0.133287 | -0.0091133821098082751,8.0825705944465985e-11,-0.0079375000007849018 | 0.11030042164559431,10.91764781540655,0.014132443108321169
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.491Z | Line String | 5333550.6899832012,2184690.1570850816,361.35899796248322 | 0 | 0 | 0 | 0,0,0 | 60.656396810896695,0.90478097926825285,0.08470757906803783
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.532Z | Extended Element | 5333550.6899832031,2184690.1570850816,361.35899796249294 | -89.1454 | 179.999 | -0.2521 | -0.0079398390499706845,3.3546023962137517e-10,-0.0079375000002842207 | 0.007937499897712634,60.66278598565615,0.23734436767603478
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.541Z | Line | 5333605.7075809976,2184677.1475213375,361.09541033978911 | 0 | 0 | 0 | 0,-0.16062615672126412,0 | 1.8982198890298605,0,7.284825187525712e-09
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.550Z | Complex Chain | 5333606.6687970022,2184677.0572082005,361.1362128586041 | 0 | 0 | 0 | -60.6470982786268,-0.9046424119733274,-0.07364944028552145 | 0,0.08207042096182704,0.028092123653721046
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.559Z | Complex Chain | 5333606.6697510052,2184676.9932475225,361.41561341600186 | 0 | 0 | 0 | -60.647098288871348,-0.90464173490181565,-0.073649480229050823 | 0,0.082070628646761179,0.028092123843293848
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.568Z | Complex Chain | 5333606.6700958759,2184676.9701273786,361.58495047173648 | 0 | 0 | 0 | -60.647098283283412,-0.90464173862710595,-0.073649476789341861 | 0,0.082070629112422466,0.028092123844373873
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.649Z | Extended Element | 5333595.7522954661,2184676.9044482694,361.5899944919438 | -89.1454 | 0.000454511 | -0.0839428 | -0.0093042257665463778,3.4493422949432463e-10,-0.0093042252077585614 | 0.10506664997035026,10.918320447632036,0.025205147327968327
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.663Z | Extended Element | 5333596.726164246,2184676.9189751088,361.60446847814194 | -89.1454 | -0.0000903303 | 179.916 | -0.0093038284123293444,1.4342693696345999e-10,-0.0079374999996020962 | 0.0093038922573197951,10.545189238643584,0.031032303653366487
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.675Z | Extended Element | 5333586.7790079182,2184676.7705983785,361.61300778763564 | -89.1454 | -0.000299463 | 179.998 | -0.009305127391412614,7.9220304794908876e-10,-0.0079375000000000018 | 0.0093052927940434089,10.922207880785404,0.031096017807631635
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.689Z | Extended Element | 5333576.8318494959,2184676.6222216152,361.6074443940833 | -89.1454 | -0.0000604194 | -179.924 | -0.0093038111513474245,5.1987497426162035e-10,-0.0079375000017783571 | 0.0093038280561813166,10.460718843893739,0.031104038628379942
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.703Z | Extended Element | 5333566.884708371,2184676.4738451126,361.58805630447762 | -89.1454 | -0.0000989114 | -179.837 | -0.0093051197202404148,3.7781867475684528e-10,-0.0079375000017250976 | 0.0093051117173423674,10.9222089178433,0.030505008275515853
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.715Z | Extended Element | 5333556.9376049843,2184676.3254691707,361.55449453893874 | -89.1454 | 0.000389625 | -179.763 | -0.0091083210460585935,-6.4203074062045793e-10,-0.0098625606723197114 | 0.10506614879948482,10.918116010069127,0.011334819753163573
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.765Z | Extended Element | 5333595.7519505955,2184676.9275683975,361.42065743620623 | -89.1454 | 0.000509487 | -0.0839428 | -0.0093042257665463778,3.4493422949432463e-10,-0.0093042252077585614 | 0.10506664997035026,10.918320447632036,0.025205147327968327
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.774Z | Extended Element | 5333596.7258193744,2184676.9420952518,361.43513142240585 | -89.1454 | -0.0000876289 | 179.916 | -0.0093038284123293444,1.4342693696345999e-10,-0.0079374999996020962 | 0.0093038922573197951,10.545189238643584,0.031032303653366487
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.784Z | Extended Element | 5333586.7786630467,2184676.793718521,361.44367073190006 | -89.1454 | 0.000432502 | 179.998 | -0.009305127391412614,7.9220304794908876e-10,-0.0079375000000000018 | 0.0093052927940434089,10.922207880785404,0.031096017807631635
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.792Z | Extended Element | 5333576.8315046243,2184676.6453417605,361.43810733834783 | -89.1454 | -0.0000575445 | -179.924 | -0.0093038111513474245,5.1987497426162035e-10,-0.0079375000017783571 | 0.0093038280561813166,10.460718843893739,0.031104038628379942
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.803Z | Extended Element | 5333566.8843635004,2184676.4969652561,361.418719248743 | -89.1454 | -0.0000951939 | -179.837 | -0.0093051197202404148,3.7781867475684528e-10,-0.0079375000017250976 | 0.0093051117173423674,10.9222089178433,0.030505008275515853
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.813Z | Extended Element | 5333556.9372601146,2184676.3485893151,361.38515748320725 | -89.1454 | 0.000393154 | -179.763 | -0.0091083210460585935,-6.4203074062045793e-10,-0.0098625606723197114 | 0.10506614879948482,10.918116010069127,0.011334819753163573
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.863Z | Extended Element | 5333595.7509965263,2184676.9915290857,361.14125687861929 | -89.1454 | 0.000518237 | -0.0839427 | -0.0093042257665463778,3.4493422949432463e-10,-0.0093042252077585614 | 0.10506664997035026,10.918320447632036,0.025205147327968327
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.872Z | Extended Element | 5333596.7248653052,2184677.0060559423,361.15573086481618 | -89.1454 | -0.0000070763 | 179.916 | -0.0093038284123293444,1.4342693696345999e-10,-0.0079374999996020962 | 0.0093038922573197951,10.545189238643584,0.031032303653366487
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.883Z | Extended Element | 5333586.7777089737,2184676.857679212,361.16427017431261 | -89.1454 | -0.000285186 | 179.998 | -0.009305127391412614,7.9220304794908876e-10,-0.0079375000000000018 | 0.0093052927940434089,10.922207880785404,0.031096017807631635
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.892Z | Extended Element | 5333576.8305505505,2184676.7093024496,361.15870678075925 | -89.1454 | -0.0000632942 | -179.924 | -0.0093038111513474245,5.1987497426162035e-10,-0.0079375000017783571 | 0.0093038280561813166,10.460718843893739,0.031104038628379942
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.900Z | Extended Element | 5333566.8834094293,2184676.5609259461,361.13931869115407 | -89.1454 | -0.0000970527 | -179.837 | -0.0093051197202404148,3.7781867475684528e-10,-0.0079375000017250976 | 0.0093051117173423674,10.9222089178433,0.030505008275515853
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.908Z | Extended Element | 5333556.9363060445,2184676.4125500047,361.10575692561736 | -89.1454 | 0.000260518 | -179.763 | -0.0091083210460585935,-6.4203074062045793e-10,-0.0098625606723197114 | 0.10506614879948482,10.918116010069127,0.011334819753163573
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.962Z | Extended Element | 5333602.4555223854,2184690.7018989553,360.92970523123068 | 90.8546 | -0.000418558 | 0.120951 | -0.0093042257217671853,-8.5650814672382918,-0.0093042252156680071 | 0.009304225683763219,1.2394349587014295,0.0252051468265857
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.975Z | Extended Element | 5333601.2045772718,2184690.6832393501,360.94824721770709 | -89.1454 | 0.00000671837 | 179.879 | -0.0093038171076020859,2.4296253894183561e-10,-0.0079375000006821229 | 0.0093038735430722042,10.656355144686168,0.030610126210294887
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:58.988Z | Extended Element | 5333591.3894873131,2184690.5368325869,360.96334469871397 | -89.1454 | -0.0000984772 | 179.965 | -0.0093038698588957074,-7.7550355515185979e-10,-0.0079375000008004779 | 0.0093038980729270564,9.9841795388769388,0.029721959386143401
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.002Z | Extended Element | 5333581.5743858516,2184690.3904256527,360.96456742912824 | -89.1454 | 0.000102185 | -179.961 | -0.0093039469250534475,-7.2215469164126514e-10,-0.0079375000025890315 | 0.0093038120378037895,10.836017700368675,0.03033936620846777
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.017Z | Extended Element | 5333571.7592916964,2184690.2440188271,360.9524605804379 | -89.1454 | 0.0000331625 | -179.874 | -0.0093039203744938216,2.3551385218389489e-10,-0.0079374999995502227 | 0.0093038735398806374,10.163876233225489,0.029489816468419226
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.027Z | Extended Element | 5333551.0235071126,2184689.9347135522,360.88238873390708 | -89.1454 | 179.999 | -0.2521 | -0.0079375354535347505,3.9943004457678997e-10,-0.0079374999994315677 | 0.007937499832414957,10.922027710788173,0.011942304249830143
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.083Z | Extended Element | 5333551.0200975742,2184690.1632885817,360.882388734009 | -89.1454 | 179.999 | -0.2521 | -0.0093040776093637756,-5.0727466675188711e-10,-0.0079375000003410641 | 0.0093038969123574022,10.574355732813771,0.027872774214809926
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.096Z | Extended Element | 5333560.8351164795,2184690.309694285,360.92274770356488 | -89.1454 | -180 | -0.18745 | -0.0093038709285469916,-2.2818835714384957e-10,-0.0079375000019326764 | 0.0093039563397880973,9.9022153011859917,0.029827819438531984
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.108Z | Extended Element | 5333570.6501800343,2184690.4561006548,360.95005170286601 | -89.1454 | 180 | -0.113434 | -0.0093038661050070907,-7.5876896639550735e-10,-0.0079375000011754227 | 0.0093038124867653345,10.754053458356454,0.030462884073682382
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.123Z | Extended Element | 5333580.4652717086,2184690.6025074427,360.96400857911414 | -89.1454 | 180 | -0.0270816 | -0.0093039864876205847,7.1232441933575976e-13,-0.0079375000012343756 | 0.0093038707487887642,10.081877853365858,0.029595750433513698
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.134Z | Extended Element | 5333590.2803732688,2184690.7489143787,360.9640696648749 | -89.1454 | 180 | 0.0469347 | -0.0093051110151783339,-5.6414183527421098e-10,-0.0079375000013416439 | 0.0093051599391539338,10.922208710057387,0.030714182760880861
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.147Z | Extended Element | 5333600.0954654478,2184690.8953211741,360.95058160631157 | -89.1454 | -180 | 0.120951 | -0.0079374994753575543,4.5901547272737869e-10,-0.0079375000015229121 | 0.0079375160237668812,10.922029847472224,0.015823475095061608
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.203Z | Extended Element | 5333600.0314629059,2184690.3863076288,360.93861798355647 | -89.1454 | 0.0046989 | -0.120951 | -0.0093042255281473793,3.9638365819280764e-10,-0.0093042251669870017 | 0.0093042255598074254,10.922230283046733,0.025205146849440797
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.215Z | Extended Element | 5333601.1400543498,2184690.4028452542,360.95217845262516 | -89.1454 | -0.0000788463 | 179.879 | -0.0093038112973486235,-1.6693142101959754e-10,-0.0079375000007424704 | 0.0093038900782050071,10.587657212987923,0.030709660746180218
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.230Z | Extended Element | 5333591.3276195368,2184690.2564780973,360.96717079348224 | -89.1454 | -0.000176184 | 179.965 | -0.0093038653650040614,2.9891311702056191e-10,-0.0079375000006530767 | 0.0093039066917683516,9.9181371882286946,0.029803844178595992
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.245Z | Extended Element | 5333581.5151733663,2184690.1101107704,360.96831003553791 | -89.1454 | -0.0000668053 | -179.961 | -0.009303812434900376,-3.1898111109413211e-10,-0.0079375000022671865 | 0.009303884374878283,10.77263093338458,0.030430895740440344
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.257Z | Extended Element | 5333571.7027346296,2184689.9637435535,360.9561134841897 | -89.1454 | 0.0000866093 | -179.874 | -0.0093039411890945833,2.2169902588789047e-10,-0.007937500000762137 | 0.0093038703216099528,10.103145049205981,0.029564839315913142
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.269Z | Extended Element | 5333550.969605743,2184689.6544778929,360.88591941817737 | -89.1454 | 179.999 | -0.2521 | -0.0079375390547900236,2.777900747393359e-10,-0.0079375000007827819 | 0.0079375000706902558,10.922027736416315,0.011889277849083269
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.324Z | Extended Element | 5333599.9605425922,2184690.1820281516,360.94282227472638 | -89.1454 | -0.000330151 | -0.120951 | -0.0093042259487361029,-1.3873174110589332e-10,-0.009304225368931952 | 0.0093042256520324187,10.92223036739121,0.025205147158604019
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.339Z | Extended Element | 5333601.0691340128,2184690.1985643599,360.95638274397629 | -89.1454 | -0.000112791 | 179.879 | -0.0093038091139262327,-8.4499509111083969e-10,-0.0079375000002448234 | 0.0093039203316130116,10.513697783522666,0.030821127509402774
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.353Z | Extended Element | 5333591.2566990014,2184690.0521971993,360.9712636185597 | -89.1454 | -0.0000993945 | 179.965 | -0.0093038690989333088,2.372888551946134e-10,-0.0079375000000000018 | 0.0093038936725182986,9.8441777145561851,0.029899386758575484
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.368Z | Extended Element | 5333581.4442527862,2184689.9058298711,360.97230731770969 | -89.1454 | 0.000106004 | -179.961 | -0.0093039324007100389,-1.0513151462502121e-10,-0.0079375000001136904 | 0.0093038107320175412,10.698671408487771,0.030542362616041412
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.381Z | Extended Element | 5333571.6318141632,2184689.7594626574,360.95999929985902 | -89.1454 | 0.000072738 | -179.874 | -0.0093039650727504992,-1.345606463987011e-10,-0.0079374999996020996 | 0.0093038715627075646,10.02918547701054,0.029660381631821886
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.392Z | Extended Element | 5333550.8986857729,2184689.4501970033,360.88964216293766 | -89.1454 | 179.999 | -0.2521 | -0.0079375383607727459,-5.9922582340879269e-10,-0.0079375000015099555 | 0.007937500025971744,10.922027764149471,0.011821748404681054
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.446Z | Extended Element | 5333599.8896223027,2184689.977747147,360.94683897718306 | -89.1454 | 0.0000648454 | -0.120951 | -0.0093042250320130131,1.1469437672454222e-10,-0.0093042252119070364 | 0.0093042254236515732,10.922230451564918,0.025205147556194834
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.459Z | Extended Element | 5333600.9982136739,2184689.9942834643,360.96039944651426 | -89.1454 | -0.0000609018 | 179.879 | -0.009303811603574904,-6.402850817862486e-11,-0.0079375000001531606 | 0.0093038497349362832,10.439738352655482,0.03093259354172128
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.471Z | Extended Element | 5333591.1857784679,2184689.8479163018,360.97516885482537 | -89.1454 | -0.0000780974 | 179.965 | -0.0093038704530063725,-8.7186924359727271e-11,-0.0079375000001136922 | 0.0093039631226856396,9.7702182358533047,0.029994930213168298
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.483Z | Extended Element | 5333581.3733322099,2184689.7015489731,360.97611701106945 | -89.1454 | -0.0000552505 | -179.961 | -0.0093038633592227721,-1.3662258377577244e-10,-0.0079375000015623146 | 0.00930382316739823,10.624711886210246,0.030653829025181566
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.496Z | Extended Element | 5333571.5608937033,2184689.5551817599,360.9636975267149 | -89.1454 | 0.0000544841 | -179.874 | -0.0093039024380900826,-2.0351795662893643e-10,-0.007937500001365793 | 0.0093038718211977574,9.9552259098724196,0.029755923986502668
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.508Z | Extended Element | 5333550.8277658019,2184689.2459161147,360.89317731888616 | -89.1454 | 180 | -0.2521 | -0.0079375110331836498,1.954552049535061e-10,-0.0079375000070429184 | 0.0079375004086585012,10.92202779641541,0.011754218970375215
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.566Z | Extended Element | 5333599.8187020142,2184689.7734662164,360.95104813438991 | -89.1454 | 0.000191841 | -0.120951 | -0.0093042254025989292,7.2187944100592522e-10,-0.0093042251818557017 | 0.0093042256338236821,10.922230535144806,0.025205146989997148
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.580Z | Extended Element | 5333600.927293336,2184689.79000257,360.96460860382069 | -89.1454 | -0.00000299941 | 179.879 | -0.0093038159312293367,4.4911526255219151e-10,-0.0079375000036958372 | 0.0093038496072332701,10.365778921520462,0.03104406000931267
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.593Z | Extended Element | 5333591.1148579307,2184689.6436354034,360.97926654585876 | -89.1454 | 0.00000948005 | 179.965 | -0.0093051839653711145,5.2302230777289186e-11,-0.0079375000013093867 | 0.009305104940597957,10.922208947206567,0.030344017676104555
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.607Z | Extended Element | 5333581.3024116326,2184689.4972680742,360.98011915919551 | -89.1454 | 0.000130245 | -179.961 | -0.0093039310988932561,1.4868355675958978e-10,-0.0079374999999999984 | 0.0093038086131670469,10.550752363293304,0.0307652951889467
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.621Z | Extended Element | 5333571.4899732387,2184689.3509008633,360.96758820834287 | -89.1454 | 0.00000887781 | -179.874 | -0.0093039065215165615,4.8538051352629476e-10,-0.0079374999999431636 | 0.0093038766939608879,9.8812663396758929,0.029851465993666448
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.635Z | Extended Element | 5333550.7568458291,2184689.0416352251,360.89690492960261 | -89.1454 | 180 | -0.2521 | -0.0079375103732727895,3.7598048919262606e-10,-0.0079375000023972925 | 0.0079375003568525181,10.922027828067186,0.011686689553699418
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.687Z | Extended Element | 5333599.7173081618,2184689.4814083683,360.95718396773145 | -89.1454 | 0.000217544 | -0.120951 | -0.009304225333206257,4.7528174610108023e-10,-0.0093042252352847389 | 0.0093042250610911349,10.922230654108516,0.025205146931848391
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.702Z | Extended Element | 5333600.8258994836,2184689.4979447294,360.97074443715849 | -89.1454 | -0.0000182934 | 179.879 | -0.0093038147946249202,-4.3664810774356386e-11,-0.00793749999880629 | 0.0093038746494689389,10.260040116208918,0.031203422059693141
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.715Z | Extended Element | 5333591.0134638622,2184689.35157756,360.98524301732442 | -89.1454 | -0.0000500005 | 179.965 | -0.0093051146095932402,3.8997166267848088e-10,-0.007937500001807209 | 0.0093051083989669769,10.922208859807489,0.030480613931697653
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.729Z | Extended Element | 5333581.2010175679,2184689.2052102317,360.98595903438223 | -89.1454 | 0.0000606599 | -179.961 | -0.0093039129079968298,-1.1905482870299915e-10,-0.0079375000013977917 | 0.0093038124852366823,10.445013555348815,0.030924657618872288
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.742Z | Extended Element | 5333571.3885794049,2184689.0588430231,360.97326872170731 | -89.1454 | 0.000118405 | -179.874 | -0.0093042015706160421,7.9336747393778206e-10,-0.0079375000005937561 | 0.0093038689023051367,9.7755275332601883,0.029988062235641759
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.755Z | Extended Element | 5333550.6554524321,2184688.7495773914,360.90235230195174 | -89.1454 | 180 | -0.2521 | -0.0079375106345136778,1.4873661021577246e-10,-0.0079374999987445443 | 0.007937500106462797,10.922028202633882,0.011590143868514731
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.814Z | Extended Element | 5333601.9775116257,2184689.2228626516,360.9586508948878 | 90.8546 | -0.000014284 | 0.108615 | -0.0093042257786898619,-8.5597713446133934,-0.0093042252832707187 | 0.00930422641599527,2.2634187091683708,0.025205147078299458
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.827Z | Extended Element | 5333600.7239075415,2184689.2041632738,360.97692855140718 | -89.1454 | 0.0000903842 | 179.891 | -0.0093038803676802062,-7.8887085755936234e-10,-0.0079374999990905089 | 0.0093038770554557254,10.153676705480324,0.02949956092113418
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.839Z | Extended Element | 5333590.9114711331,2184689.0577960927,360.99104945002381 | -89.1454 | -0.000135073 | 179.965 | -0.0093050953392092763,-1.5345820643584479e-10,-0.0079375000009583481 | 0.0093051828233413209,10.922208770569251,0.030618016670114406
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.851Z | Extended Element | 5333581.0990247149,2184688.9114287626,360.99162806422083 | -89.1454 | 0.0000456666 | -179.961 | -0.0093039124861901325,5.6784972094337111e-10,-0.0079375000014136228 | 0.0093038142906296927,10.338650319608535,0.031084960903554608
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.864Z | Extended Element | 5333571.2865866488,2184688.7650615559,360.97877744833301 | -89.1454 | 0.0000582551 | -179.874 | -0.0093052126870914898,3.900629673666276e-10,-0.0079375000026429016 | 0.0093050996659375333,10.922208928388477,0.03037899519104667
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.875Z | Extended Element | 5333550.5534606483,2184688.4557959377,360.90762651280602 | -89.1454 | 179.999 | -0.2521 | -0.0079375363989560785,7.2754096078127771e-11,-0.0079375000019705922 | 0.0079374998521039124,10.922027914548321,0.011493027812156166
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.930Z | Extended Element | 5333610.4343222305,2184689.0567485546,360.9560727393287 | -89.1454 | -0.000055047 | 179.805 | -0.0093038310516265019,-4.9159595047771685e-10,-0.0079375000011465049 | 0.0093038198920098649,10.716825762662813,0.030568999560044476
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.943Z | Extended Element | 5333600.6219151868,2184688.9103818112,360.98394753828171 | -89.1454 | 0.000116256 | 179.891 | -0.0093038826538501714,8.8508647877664995e-10,-0.0079375000006120904 | 0.0093038989441293265,10.047313800698312,0.02963696356599865
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.957Z | Extended Element | 5333590.8094785409,2184688.7640146278,360.99793103475201 | -89.1454 | 0.0000139418 | 179.965 | -0.0093043658485956245,-2.3308427749491285e-10,-0.0079375000006787141 | 0.0093038254553746494,10.901797721594974,0.030236223007292898
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.970Z | Extended Element | 5333580.9970318722,2184688.6176472926,360.99860655134472 | -89.1454 | -0.000100814 | -179.948 | -0.0093038861359840269,-7.7549552136853032e-11,-0.0079375000006676084 | 0.0093038824247546077,10.232286842215872,0.02939801789639334
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.983Z | Extended Element | 5333571.1845941581,2184688.4712800924,360.98536132766708 | -89.1454 | -0.0000752899 | -179.874 | -0.0093050979617965001,-6.3383953609437252e-10,-0.0079375000012583234 | 0.0093051817199851488,10.922208838670736,0.030516396812475616
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:59.996Z | Extended Element | 5333550.4514688626,2184688.1620144844,360.9139758757774 | -89.1454 | 180 | -0.2521 | -0.0079375109725798726,-5.4910386405242754e-10,-0.0079375000043752069 | 0.0079375002310669435,10.922027960656457,0.011395912050918562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.064Z | Extended Element | 5333610.3323304476,2184688.7629671013,360.96188758696331 | -89.1454 | -0.000116339 | 179.805 | -0.0093038087290429027,4.1042356531311213e-10,-0.0079375000006652579 | 0.0093038513091737666,10.610462962442911,0.03067527334635671
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.081Z | Extended Element | 5333600.5199228628,2184688.61660035,360.98959158820793 | -89.1454 | 0.0000922445 | 179.891 | -0.0093039205259933481,-3.2719515986948627e-10,-0.0079375000016484627 | 0.00930387003277049,9.9409509273623762,0.029774365648349892
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.097Z | Extended Element | 5333590.707485972,2184688.4702331615,361.00343768257744 | -89.1454 | -0.0000838941 | 179.965 | -0.0093038122131759611,1.5937066709117393e-10,-0.0079375000008049014 | 0.0093039094215901143,10.795434775477229,0.030396524966124074
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.110Z | Extended Element | 5333580.8950392529,2184688.3238658267,361.00395289613135 | -89.1454 | -0.0000962793 | -179.948 | -0.0093038693816346971,7.1187348986858068e-11,-0.0079375000010612432 | 0.0093039407639474939,10.125923822421381,0.029535420415913439
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.125Z | Extended Element | 5333571.0826016767,2184688.1774986279,360.99057027011804 | -89.1454 | 0.000106054 | -179.874 | -0.0093051599815665662,-4.3564489484276485e-10,-0.0079375000033116167 | 0.0093050969137251222,10.922208750178013,0.030653798430660059
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.154Z | Extended Element | 5333550.3494770788,2184687.8682330307,360.91895030187123 | -89.1454 | 179.999 | -0.2521 | -0.007937531286624798,2.1772725203664255e-10,-0.0079375000026957604 | 0.0079375006637273614,10.922028005292773,0.011298796287249398
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.207Z | Extended Element | 5333610.2303386619,2184688.4691856476,360.96774379305754 | -89.1454 | -0.0000919733 | 179.805 | -0.0093038103357776254,-2.2906771613987468e-10,-0.0079375000082999858 | 0.0093038397264747549,10.504100204120711,0.030835574963705481
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.222Z | Extended Element | 5333600.4179305723,2184688.3228188888,360.99528749345382 | -89.1454 | 0.000122338 | 179.891 | -0.0093038832790781571,-2.8996099501199271e-10,-0.0079375000003429601 | 0.0093039128538306981,9.8345880877017056,0.029911767904230273
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.236Z | Extended Element | 5333590.6054934263,2184688.176451697,361.00899618576949 | -89.1454 | -0.00013398 | 179.965 | -0.0093038069587575156,-1.3959370311105094e-10,-0.0079375000016338442 | 0.0093038370725291256,10.689071852509926,0.030556827819579444
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.249Z | Extended Element | 5333580.7930466477,2184688.0300843613,361.00935109631189 | -89.1454 | -0.0000624866 | -179.948 | -0.0093039654941900838,7.9049922161846412e-10,-0.0079375000001136887 | 0.0093038806928665112,10.019560814640819,0.029672822852113711
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.263Z | Extended Element | 5333570.9806092009,2184687.8837171635,360.99583106796996 | -89.1454 | 0.0000923421 | -179.874 | -0.0093038265757888015,6.2994298662059102e-10,-0.0079374999997726282 | 0.0093038097010440992,10.87408762122584,0.030277984927690585
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.274Z | Extended Element | 5333550.247485294,2184687.5744515778,360.92397658333709 | -89.1454 | 179.999 | -0.2521 | -0.0079375297792449503,8.2448810564555778e-11,-0.0079375000027854508 | 0.00793749978552649,10.92202652508117,0.01097334582289437
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.330Z | Extended Element | 5333610.1283468772,2184688.1754041938,360.97396361237645 | -89.1454 | -0.0000659239 | 179.805 | -0.0093038113325494762,-1.9192536452557437e-10,-0.0079375000026147974 | 0.0093038273988711104,10.397737446473572,0.030995876556879836
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.343Z | Extended Element | 5333600.3159382818,2184688.0290374272,361.00134701192513 | -89.1454 | 0.0000891958 | 179.891 | -0.0093051126256889459,-2.5491941905761323e-11,-0.0079375000000568453 | 0.0093059752485928366,10.922208975722336,0.030302712154051392
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.356Z | Extended Element | 5333590.5035008788,2184687.8826702326,361.01491830218663 | -89.1454 | -0.000180914 | 179.965 | -0.0093038044521472178,3.060364055254312e-10,-0.0079375000014290948 | 0.0093039047037330215,10.582708928379812,0.03071713154831324
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.369Z | Extended Element | 5333580.6910540424,2184687.7363028945,361.01511290971638 | -89.1454 | -0.0000266404 | -179.948 | -0.0093039213441490892,2.2539137299011454e-10,-0.0079375000019347355 | 0.0093038789864548638,9.9131978074855329,0.0298102251817523
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.383Z | Extended Element | 5333570.878616727,2184687.5899357004,361.00145547904896 | -89.1454 | 0.0000740072 | -179.874 | -0.0093038226367429394,-4.6839876426640457e-10,-0.0079375000009094965 | 0.009303822171726598,10.767724532473213,0.030438287386034379
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.393Z | Extended Element | 5333550.1454935083,2184687.2806701246,360.92936647802105 | -89.1454 | 179.999 | -0.2521 | -0.0079375288014970485,2.2337820478923063e-10,-0.0079375000031832316 | 0.0079375000471510158,10.92202655001716,0.010899130234358319
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.451Z | Extended Element | 5333610.026953483,2184687.8833463602,360.98014769314142 | -89.1454 | -0.0000538485 | 179.805 | -0.0093038124557119212,-4.9978809066755188e-10,-0.0079375000039791383 | 0.0093038261171904148,10.291998721458912,0.03115523747223399
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.463Z | Extended Element | 5333600.2145443782,2184687.7369795865,361.00737173232903 | -89.1454 | 0.00013175 | 179.891 | -0.0093051999018048566,2.924448315975642e-10,-0.0079375000032624599 | 0.0093050930798405616,10.922208888301622,0.030439308217752571
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.476Z | Extended Element | 5333590.4021067256,2184687.5906123873,361.02080642668 | -89.1454 | -0.000057906 | 179.965 | -0.009303811055267508,1.0269696783058885e-10,-0.0079375000004088207 | 0.0093038258322304078,10.476970037527281,0.030876493282646102
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.490Z | Extended Element | 5333580.5896598287,2184687.4442450502,361.02084167169647 | -89.1454 | -0.000109505 | -179.948 | -0.0093040323957166021,-2.3284269835279333e-11,-0.0079375000013985654 | 0.0093038842370078458,9.8074588345720812,0.02994682174729774
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.504Z | Extended Element | 5333570.7772226417,2184687.2978778561,361.00704764484163 | -89.1454 | -0.0000416109 | -179.874 | -0.0093038130983943198,2.2144727697549831e-10,-0.00793750000283454 | 0.0093038222039695615,10.661985475624633,0.030597648735008958
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.517Z | Extended Element | 5333550.0441001123,2184686.9886122905,360.93472550334877 | -89.1454 | 180 | -0.2521 | -0.0079375099808456744,2.2267033557904001e-11,-0.0079375000001486 | 0.0079374997951145165,10.922026574612008,0.010825350077861257
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.585Z | Extended Element | 5333601.3972276933,2184687.5513980719,360.99305056432769 | 90.8546 | 0.0000131266 | 0.108615 | -0.0093042256820393653,-8.5597712684176841,-0.0093042252348732989 | 0.0093042257317905407,1.6582686131607025,0.025205147574982295
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.600Z | Extended Element | 5333600.1436240552,2184687.5326986918,361.01132822001665 | -89.1454 | 0.0000545483 | 179.891 | -0.0093051604387899781,5.5281677486758406e-10,-0.007937500003071328 | 0.009305099635942355,10.922208827527735,0.030534850796041721
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.617Z | Extended Element | 5333590.3311862238,2184687.3863314893,361.02466737186643 | -89.1454 | -0.000103944 | 179.965 | -0.0093038086642568043,2.7380825946220673e-10,-0.0079375000031199974 | 0.009303865906471899,10.403010596516367,0.030987960072088972
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.631Z | Extended Element | 5333580.5187392887,2184687.2399641518,361.02459115021139 | -89.1454 | 0.0000486059 | -179.948 | -0.0093074896725071649,4.9361015004584489e-10,-0.007937500001677162 | 0.0093051069703785887,10.922208981001761,0.030295904339811181
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.643Z | Extended Element | 5333570.7063021921,2184687.0935969595,361.01070158067574 | -89.1454 | 0.000053887 | -179.874 | -0.0093038357522717014,-5.6941871315640223e-10,-0.0079375000015379695 | 0.0093038122850627701,10.588025920160341,0.030709113856525812
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.656Z | Extended Element | 5333549.9731801413,2184686.7843314013,360.93821636824197 | -89.1454 | 180 | -0.2521 | -0.007937512813741561,-7.8027850850150328e-10,-0.0079375000017621565 | 0.0079375000608617394,10.922026593836199,0.01077374428452858
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.713Z | Extended Element | 5333601.326307307,2184687.3471172261,360.99725477786137 | 90.8546 | 0.000198924 | 0.108615 | -0.0093042255232720014,-8.5597714716289293,-0.0093042251159203716 | 0.0093042260552199524,1.5843091661745969,0.025205147370766623
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.725Z | Extended Element | 5333600.0727037303,2184687.328417798,361.01553243343437 | -89.1454 | 0.000120702 | 179.891 | -0.009305111902790042,1.7023127348724882e-10,-0.0079375000003979006 | 0.0093051206425768841,10.92220876515405,0.030630393382231384
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.739Z | Extended Element | 5333590.2602657229,2184687.1820505927,361.02877604278524 | -89.1454 | 0.000037208 | 179.965 | -0.0093038234985647374,-2.668568422048938e-10,-0.0079374999998863185 | 0.0093038162523709361,10.329051150019341,0.031099426920593462
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.753Z | Extended Element | 5333580.4478187449,2184687.0356832547,361.02858835444863 | -89.1454 | -0.0000956617 | -179.948 | -0.009305432926806868,5.5286847321438434e-10,-0.007937499999886315 | 0.0093051117054957465,10.922208920023083,0.030391447146084407
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.766Z | Extended Element | 5333570.6353817368,2184686.8893160629,361.0146032422179 | -89.1454 | -0.0000431312 | -179.874 | -0.0093038129318860577,-3.378113977859212e-10,-0.0079375000042274484 | 0.0093038571753922047,10.514066357138082,0.030820580375494285
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.776Z | Extended Element | 5333549.9022601694,2184686.5800505118,360.94195495885583 | -89.1454 | 180 | -0.2521 | -0.0079375077768080934,-2.0392378902205893e-10,-0.00793750000630398 | 0.0079375000907286435,10.922026609671761,0.010722138482520599
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.829Z | Extended Element | 5333601.2249133242,2184687.0550593375,361.00326548928393 | 90.8546 | 0.0000269155 | 0.108615 | -0.0093042256106332013,-8.5597717546685459,-0.0093042251637200368 | 0.0093042257479559846,1.4785702747748628,0.025205147293634562
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.842Z | Extended Element | 5333599.9713098258,2184687.0363599565,361.02154314470459 | -89.1454 | 0.0000736886 | 179.891 | -0.0093042153302294161,-3.6456733413800976e-11,-0.007937500000286337 | 0.0093038188395142326,10.892832620534312,0.030249727007583677
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.855Z | Extended Element | 5333590.1588716805,2184686.8899927493,361.03488253297434 | -89.1454 | 0.0000988335 | 179.978 | -0.0093039047599212943,7.7011310864025935e-10,-0.0079375000014538927 | 0.0093038699460401397,10.223311821725867,0.029409612967950104
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.870Z | Extended Element | 5333580.3464245303,2184686.7436254085,361.03430310729243 | -89.1454 | -0.0000637873 | -179.948 | -0.0093050985566362019,-2.3780703608205265e-10,-0.0079374999995452528 | 0.0093051276923236011,10.922208829587767,0.030528043303640028
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.883Z | Extended Element | 5333570.5339876534,2184686.59725822,361.02018139887633 | -89.1454 | 0.000101981 | -179.874 | -0.0093038262062952581,2.2091499885909425e-11,-0.0079375000007579181 | 0.0093038297192590373,10.408327301863274,0.030979941704075361
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.894Z | Extended Element | 5333549.8008667734,2184686.2879926786,360.94729997504163 | -89.1454 | 180 | -0.2521 | -0.0079375107717249219,2.5919837001710462e-10,-0.0079374999987037731 | 0.0079375004349061667,10.922026633976749,0.010648358333429031
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.949Z | Extended Element | 5333601.122920949,2184686.7612779886,361.00938554047707 | 90.8546 | 0.000443101 | 0.108615 | -0.0093042254888647206,-8.5597720423386825,-0.0093042251232843022 | 0.00930422536860156,1.3722073514921378,0.02520514736369555
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.960Z | Extended Element | 5333599.8693175381,2184686.7425784962,361.02766319573203 | -89.1454 | 0.0000358118 | 179.891 | -0.0093038233647991832,-6.7884975424201453e-10,-0.0079374999993178878 | 0.0093038136399873923,10.786469781145655,0.030410027692083931
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.973Z | Extended Element | 5333590.0568791246,2184686.5962112849,361.04084228152868 | -89.1454 | 0.0000102094 | 179.978 | -0.0093038781673396263,-3.42847056334017e-10,-0.0079375000000568453 | 0.0093039163754909393,10.116948897943017,0.029547014845874124
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:00.987Z | Extended Element | 5333580.2444319278,2184686.4498439431,361.04012545325372 | -89.1454 | -0.0000815112 | -179.948 | -0.0093051105240747264,-1.3269036473986409e-10,-0.0079375000015027512 | 0.0093051111672176594,10.922208741957506,0.03066544557860737
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.002Z | Extended Element | 5333570.4319951814,2184686.3034767555,361.02586634251543 | -89.1454 | 0.0000896755 | -179.874 | -0.0093038372978679444,-4.9768820664305781e-11,-0.007937500002360166 | 0.0093038094298825078,10.301964216998364,0.03114024353642704
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.013Z | Extended Element | 5333549.6988749877,2184685.9942112258,360.95275040229245 | -89.1454 | 180 | -0.2521 | -0.0079375102361898733,5.9687321749477774e-10,-0.0079374999971578344 | 0.0079375000158090382,10.922026664831563,0.010574142750653583
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.073Z | Extended Element | 5333601.0209285747,2184686.4674964962,361.01535785709609 | 90.8546 | 0.000331313 | 0.108615 | -0.0093042250114431391,-8.5597723283908973,-0.0093042252447289846 | 0.0093042260505740611,1.2658444260080965,0.025205146928035452
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.089Z | Extended Element | 5333599.7673252439,2184686.448797035,361.03363551219718 | -89.1454 | 0.0000703613 | 179.891 | -0.0093039251106952839,5.3701644243568495e-10,-0.0079375000024257143 | 0.0093038132691810136,10.680106937895612,0.030570330959723519
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.103Z | Extended Element | 5333589.9548865678,2184686.3024298195,361.04665429552085 | -89.1454 | -0.0000146177 | 179.978 | -0.0093038741455190605,-7.3271664271139998e-10,-0.0079375000015264267 | 0.0093039120739724663,10.01058597393261,0.029684417999508869
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.117Z | Extended Element | 5333580.1424393216,2184686.1560624773,361.04580006465346 | -89.1454 | -0.000110846 | -179.948 | -0.0093038110717433599,2.1094127910884874e-10,-0.0079375000016702908 | 0.009303977425947331,10.865082003736031,0.030291562198804772
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.131Z | Extended Element | 5333570.330002185,2184686.0096952845,361.03162994983234 | -89.1454 | -0.0000754723 | -179.862 | -0.0093038715974515986,-7.9869444439309878e-11,-0.0079374999985789164 | 0.0093039263241890893,10.19560068872978,0.029445403234567635
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.141Z | Extended Element | 5333549.596883202,2184685.7004297716,360.95805309497536 | -89.1454 | 180 | -0.2521 | -0.0079375079580049669,1.1579825189410314e-10,-0.0079375000014210925 | 0.0079375003913276232,10.922026691053407,0.010499927170337646
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.200Z | Extended Element | 5333598.5567455413,2184686.1384794926,361.0259088492283 | -89.1454 | -0.000566581 | -0.108615 | -0.0093042258102483816,1.7478576940749973e-10,-0.0093042252042417686 | 0.0093042250431849723,10.922230299051968,0.025205147007344535
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.213Z | Extended Element | 5333599.6653329534,2184686.1550155743,361.03970803053335 | -89.1454 | -0.0000674578 | 179.891 | -0.009303826340882183,-3.8273995089062273e-10,-0.0079374999998294716 | 0.0093038209212799438,10.573744096322161,0.030730633396266686
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.227Z | Extended Element | 5333589.85289401,2184686.0086483546,361.05256651138518 | -89.1454 | 0.000214131 | 179.978 | -0.0093039380847039239,2.1914307317473362e-10,-0.0079375000007148137 | 0.0093038611422948808,9.9042230503078823,0.029821820641397174
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.241Z | Extended Element | 5333580.0404467173,2184685.8622810114,361.05157487792076 | -89.1454 | -0.0000701475 | -179.948 | -0.0093038113571994076,4.5969376251489148e-10,-0.0079375000012857182 | 0.0093038496130254077,10.758718996440518,0.030451864727258089
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.255Z | Extended Element | 5333570.2280097594,2184685.7159138215,361.03724446048705 | -89.1454 | -0.0000653255 | -179.862 | -0.0093038713688747138,-5.5316085077070891e-11,-0.0079375000004547509 | 0.0093039569013713842,10.089237596331937,0.029582804646304743
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.266Z | Extended Element | 5333549.4948914191,2184685.4066483174,360.96345598952496 | -89.1454 | 180 | -0.2521 | -0.0079375074873433114,4.5681490424723697e-11,-0.0079375000006821385 | 0.0079375001465534535,10.922026712917791,0.01042571158384807
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.320Z | Extended Element | 5333598.4547533346,2184685.8446977669,361.03192869747267 | -89.1454 | 0.000374295 | -0.108615 | -0.0093042258811662313,-1.9612140702914709e-11,-0.0093042252302735964 | 0.0093042254855527761,10.922230419973955,0.025205147270972443
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.334Z | Extended Element | 5333599.5633406574,2184685.8612341126,361.04572787898582 | -89.1454 | 0.0000630626 | 179.891 | -0.00930384064739565,2.7044192374875723e-10,-0.0079375000016005826 | 0.0093038120333483916,10.467381255370615,0.030890936105253588
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.347Z | Extended Element | 5333589.7509014504,2184685.7148668892,361.05842605736348 | -89.1454 | 0.0000826601 | 179.978 | -0.0093040464439678103,-1.3691657625493713e-10,-0.0079375000008121161 | 0.0093038711884741859,9.7978601244222361,0.029959223576431604
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.362Z | Extended Element | 5333579.9384541102,2184685.5684995451,361.05729702130435 | -89.1454 | -0.0000161439 | -179.948 | -0.0093038162868059899,-5.7175935424632206e-10,-0.0079375000027367224 | 0.0093039063193159129,10.652355988818591,0.030612167328607442
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.373Z | Extended Element | 5333570.1260173386,2184685.4221323589,361.04280630126681 | -89.1454 | -0.000150063 | -179.862 | -0.0093038667873077286,8.5428453199117778e-10,-0.0079375000002273773 | 0.0093039149933749499,9.9828745105408974,0.029720206795961362
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.383Z | Extended Element | 5333549.3928996362,2184685.1128668655,360.96880621419683 | -89.1454 | 180 | -0.2521 | -0.0079375100217710416,5.9160787376253432e-10,-0.0079375000028421797 | 0.0079375002302278577,10.922026738259238,0.010351496005635365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.433Z | Extended Element | 5333598.3527611252,2184685.5509163993,361.03797488049173 | -89.1454 | 0.0000446014 | -0.108615 | -0.0093042261356889849,3.4415971421219727e-10,-0.0093042251519011715 | 0.0093042254838824872,10.922230540503357,0.025205147414404036
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:01.447Z | Extended Element | 5333599.4613483688,2184685.5674526514,361.05177406215876 | -89.1454 | 0.000195428 | 179.891 | -0.0093038980030067282,1.8797782009587056e-10,-0.0079375000023508401 | 0.0093038003632378487,10.361018415589532,0.031051239168226514
