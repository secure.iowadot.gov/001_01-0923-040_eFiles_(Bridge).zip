Properties of the parts of a building model (IFC4X3_ADD2), part 29 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.679Z | Complex Chain | 5333610.9783763504,2184691.1513282098,360.2458477791522 | 0 | 0 | 0 | -0.91467183828353882,-0.84335940750315785,0 | 0,0,1.1095066270172538e-06
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.692Z | Circle | 5333609.0026212689,2184683.8758454123,360.74465946929553 | 0 | 0 | 0 | -0.00241588790811555,-0.0048884120763032805,-0.014905212775080751 | 0.014080781386270686,0.00083871884203842988,0.0025573221601477292
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.701Z | Line | 5333609.0084537156,2184683.8738205652,360.73848552398744 | 0 | 0 | 0 | 0,-0.0020248470827937126,0 | 0.0058324597775936127,0,0.0061739314081137309
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.710Z | Complex Chain | 5333611.3835017029,2184691.1653129729,360.60734811032648 | 0 | 0 | 0 | -2.4589195912703872,-7.5330797010101378,-3.086654487560736e-09 | 0.006440233439207077,0,0.13411515353476489
Circle | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.723Z | Circle | 5333609.0105930204,2184683.8545927992,360.47594251523856 | 0 | 0 | 0 | -0.011441148641671792,-0.0017551227692419471,-0.016781877705843065 | 0.0050555205076595697,0.0039720085669213718,0.00068065722938560717
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.732Z | Line | 5333609.0074002063,2184683.8557012416,360.46789190484338 | 0 | 0 | 0 | 0,-0.0026403339579701424,-0.0033797495862586402 | 0.007605324499309063,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.744Z | Complex Chain | 5333611.3835014123,2184691.1653106138,360.33675448971633 | 0 | 0 | 0 | -2.4589195912703872,-7.5330797014757991,-3.0848354981571902e-09 | 0.0064402343705296516,0,0.13411515353567438
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.755Z | Complex Chain | 5333606.7156614326,2184676.8192672874,360.62320484709409 | 0 | 0 | 0 | -0.0064402176067233086,0,0 | 2.4590115621685982,7.533342782407999,0.11734534938352681
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.764Z | Line | 5333609.0084537156,2184683.8738205652,360.73848552398744 | 0 | 0 | 0 | -3.2596290111541748e-07,-2.7939677238464355e-09,-0.27059362060833791 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.775Z | Complex Chain | 5333606.7156611057,2184676.8192672846,360.35261122648575 | 0 | 0 | 0 | -0.0064402166754007339,0,0 | 2.4590115630999207,7.533342782407999,0.11734534938352681
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.787Z | Line | 5333610.9703563787,2184690.7272990434,360.58712140272843 | 0 | 0 | 0 | -3.8929283618927002e-07,-3.2596290111541748e-09,-0.32385064770130612 | 0,0,0
Line | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.797Z | Line | 5333610.9703559894,2184690.7272990402,360.26327075502712 | 0 | 0 | 0 | -3.9301812648773193e-07,-3.2596290111541748e-09,-0.32543815087569783 | 0,0,0
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.808Z | Complex Chain | 5333610.9607747961,2184691.159005018,360.5871214095921 | 0 | 0 | 0 | -2.4589195903390646,-7.5330797005444765,-3.0839260034554172e-09 | 0.006440233439207077,0,0.13411515353476489
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.817Z | Complex Chain | 5333610.9607744049,2184691.1590050152,360.26327076189079 | 0 | 0 | 0 | -2.4589195903390646,-7.5330797014757991,-3.0839260034554172e-09 | 0.0064402343705296516,0,0.13411515353567438
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.828Z | Complex Chain | 5333610.9607740128,2184691.1590050119,359.93783261101601 | 0 | 0 | 0 | -2.458919589407742,-7.5330797010101378,-3.0857449928589631e-09 | 0.006440233439207077,0,0.13411515353385539
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.838Z | Complex Chain | 5333606.2929375228,2184676.8129617344,360.60389121374243 | 0 | 0 | 0 | -0.0064402176067233086,0,0 | 2.4590115612372756,7.5333427819423378,0.1173453493844363
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.847Z | Complex Chain | 5333606.2929371335,2184676.8129617311,360.28004056604203 | 0 | 0 | 0 | -0.0064402166754007339,0,0 | 2.4590115621685982,7.5333427814766765,0.1173453493844363
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.857Z | Complex Chain | 5333606.2929367414,2184676.8129617274,359.95460241516543 | 0 | 0 | 0 | -0.0064402176067233086,0,0 | 2.4590115630999207,7.5333427819423378,0.11734534938352681
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.875Z | Smart Solid | 5333609.4152488206,2184687.3509226656,360.47419604156511 | 0 | 0 | 0 | -1.6579170655962667,-3.3790990391584677,-0.67920180822361109 | 1.6579050024634012,3.3790988032111553,0.6804214136499267
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.889Z | Smart Solid | 5333607.0748897558,2184680.6096533313,360.47428161677163 | 0 | 0 | 0 | -1.6579108047382198,-3.3790989470412884,-0.679284495050265 | 1.6579050024632458,3.3790988031698443,0.68033583844318835
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.903Z | Smart Solid | 5333610.5818380164,2184690.9628425613,360.40749573210638 | 0 | 0 | 0 | -0.49133779495992547,-0.24974945788564362,-0.61250149859895708 | 0.49131598558033329,0.24972618432746735,0.61371546057386861
Bspline Curve | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.912Z | Bspline Curve | 5333606.2227831353,2184676.7611085144,361.03300872144348 | 0 | 0 | 0 | 0,0,-0.00050835437650675885 | 0.17564345616847277,0.0026199850253760815,0
Smart Solid | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.925Z | Smart Solid | 5333605.908317836,2184676.9977566064,360.4151419711564 | 0 | 0 | 0 | -0.49013187604683828,-0.24854258867954723,-0.62014156197005987 | 0.49010875443224422,0.24851919390006103,0.62013443473507845
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.939Z | Extended Element | 5333606.3912246842,2184677.2462757798,358.72820041263378 | 0.514446 | 89.9999 | 90.3401 | 8.8817841970012523e-16,-1.1813237055235959e-09,9.1494312126627619e-10 | 1.0668000000000006,0.97308415397065595,0.48260000091495159
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.963Z | Extended Element | 5333605.497092383,2184677.0551193031,358.80440164182602 | -67.7257 | -0.0000255297 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:26.991Z | Extended Element | 5333605.5005019158,2184676.8265442727,358.80440164083137 | -67.7257 | -0.0000255491 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.019Z | Extended Element | 5333606.3123403303,2184677.002185063,358.80440066224804 | -67.7257 | -0.0000255437 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.045Z | Extended Element | 5333606.3141398076,2184676.8815482422,358.80440066138698 | -67.7257 | -0.0000255437 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.072Z | Extended Element | 5333606.3105408559,2184677.1228218852,358.80440066310922 | -67.7257 | -0.0000255437 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.087Z | Extended Element | 5333611.0647451505,2184691.211360692,358.72819463929005 | 0.514446 | 89.9999 | 90.3401 | -1.127986593019159e-13,-2.2784707454093223e-10,4.4932929599283966e-10 | 1.0667999999998869,0.97308415492413525,0.48260000044933155
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.114Z | Extended Element | 5333610.9907536646,2184690.8498536893,358.80439488482483 | -67.7256 | -0.0000255416 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.142Z | Extended Element | 5333610.9889541902,2184690.970490511,358.8043948856851 | -67.7256 | -0.0000255535 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.169Z | Extended Element | 5333610.9871547129,2184691.0911273309,358.80439488654702 | -67.7256 | -0.0000255319 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.195Z | Extended Element | 5333610.1690975176,2184691.1217921521,358.8043958703816 | -67.7256 | -0.0000255632 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.223Z | Extended Element | 5333610.1725070495,2184690.8932171208,358.80439586848678 | -67.7256 | -0.0000255514 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.236Z | Extended Element | 5333611.0719430437,2184690.7288143728,358.72819463584403 | -109.145 | 0.0000231914 | 89.9999 | -7.3590111782095846e-10,5.773159728050814e-14,-2.2934548601307765 | 7.4687791245210917,1.0668000000000575,3.2078548598578722
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.263Z | Extended Element | 5333610.1623183768,2184690.6644392554,358.80439588294081 | -67.7256 | -0.0000255751 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.287Z | Extended Element | 5333610.9612002876,2184690.6421670737,358.80439492306203 | -67.7256 | -0.0000255438 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.311Z | Extended Element | 5333610.8654010035,2184690.3662227872,358.80439504086394 | -67.7256 | -0.0000255535 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.338Z | Extended Element | 5333610.7404454239,2184690.0062954561,358.80439519398635 | -67.7256 | -0.0000255416 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.363Z | Extended Element | 5333610.6154898414,2184689.6463681292,358.8043953491715 | -67.7256 | -0.0000255513 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.391Z | Extended Element | 5333609.7706813896,2184689.5363513674,358.85678397149564 | -67.7256 | -0.0000255535 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.417Z | Extended Element | 5333610.4905343233,2184689.2864408004,358.85678310926818 | -67.7256 | -0.0000255847 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.444Z | Extended Element | 5333609.6507516494,2184689.1909006857,358.85678411996355 | -67.7256 | -0.0000255373 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.472Z | Extended Element | 5333610.3706045821,2184688.9409901188,358.85678325659512 | -67.7256 | -0.0000255556 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.500Z | Extended Element | 5333609.5308219111,2184688.8454500064,358.85678426775996 | -67.7256 | -0.0000255632 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.529Z | Extended Element | 5333610.2506748401,2184688.5955394404,358.8567834045968 | -67.7256 | -0.000025575 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.558Z | Extended Element | 5333609.4108921709,2184688.4999993294,358.85678441612959 | -67.7256 | -0.0000255298 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.584Z | Extended Element | 5333610.1307451036,2184688.250088763,358.85678355259961 | -67.7256 | -0.0000255438 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.615Z | Extended Element | 5333609.2909624316,2184688.1545486501,358.85678456360819 | -67.7256 | -0.0000255653 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.643Z | Extended Element | 5333610.0108153643,2184687.9046380837,358.85678370060231 | -67.7256 | -0.000025575 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.671Z | Extended Element | 5333609.8858597903,2184687.5447107553,358.85678385451041 | -67.7256 | -0.0000255653 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.697Z | Extended Element | 5333609.7609042656,2184687.1847834224,358.90869424753038 | -67.7256 | -0.0000255298 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.723Z | Extended Element | 5333608.9160957504,2184687.0747666601,358.90917263129211 | -67.7256 | -0.0000255179 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.746Z | Extended Element | 5333609.6359486785,2184686.824856095,358.90917176790475 | -67.7256 | -0.0000255395 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.772Z | Extended Element | 5333608.7961660102,2184686.7293159836,358.90917277940747 | -67.7256 | -0.0000255416 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.798Z | Extended Element | 5333609.5160189392,2184686.4794054176,358.90917191597458 | -67.7256 | -0.0000255492 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.825Z | Extended Element | 5333608.6762362756,2184686.3838653099,358.90917292770001 | -67.7256 | -0.0000255201 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.850Z | Extended Element | 5333609.3960892027,2184686.1339547439,358.90917206386098 | -67.7256 | -0.0000255395 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.878Z | Extended Element | 5333608.5563065326,2184686.0384146315,358.90917307526752 | -67.7256 | -0.0000255729 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.904Z | Extended Element | 5333609.2761594653,2184685.7885040669,358.90917221187732 | -67.7256 | -0.0000255395 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.932Z | Extended Element | 5333608.4363767952,2184685.6929639564,358.90917322319939 | -67.7256 | -0.0000255395 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.961Z | Extended Element | 5333609.1562297279,2184685.4430533908,358.90917235989463 | -67.7256 | -0.0000255395 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:27.984Z | Extended Element | 5333609.0312741492,2184685.0831260607,358.90917251368643 | -67.7256 | -0.0000255589 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.009Z | Extended Element | 5333608.9063185686,2184684.7231987328,358.91234767423765 | -67.7256 | -0.0000255437 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.037Z | Extended Element | 5333608.0615100507,2184684.6131819673,358.9123486917893 | -67.7256 | -0.0000255631 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.063Z | Extended Element | 5333608.7813629843,2184684.3632714022,358.91234782868622 | -67.7256 | -0.0000255729 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.090Z | Extended Element | 5333607.9415803133,2184684.2677312884,358.91234883968576 | -67.7256 | -0.0000255847 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.117Z | Extended Element | 5333608.6614332451,2184684.0178207215,358.91234797678419 | -67.7256 | -0.0000255631 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.129Z | Extended Element | 5333605.418248768,2184677.2317624041,358.72820158333207 | 70.8546 | -0.0000231914 | 90.0001 | 2.5848301277164865e-10,1.1102230246251565e-15,-2.2934548615852646 | 7.4687791255154732,1.0668000000000006,3.2078548584033757
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.157Z | Extended Element | 5333607.821650574,2184683.9222806129,358.91234898774019 | -67.7256 | -0.000025575 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.183Z | Extended Element | 5333608.5415035076,2184683.6723700464,358.91234812489677 | -67.7256 | -0.0000255416 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.210Z | Extended Element | 5333607.7017208375,2184683.5768299364,358.9123491357247 | -67.7256 | -0.0000255416 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.239Z | Extended Element | 5333608.4215737712,2184683.3269193703,358.91234827311763 | -67.7257 | -0.0000255394 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.267Z | Extended Element | 5333607.5817910982,2184683.2313792584,358.91234928404816 | -67.7256 | -0.0000255491 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.298Z | Extended Element | 5333608.3016440338,2184682.9814686934,358.91234842091768 | -67.7257 | -0.000025561 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.322Z | Extended Element | 5333608.1766884578,2184682.6215413627,358.91234857453333 | -67.7257 | -0.0000255319 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.346Z | Extended Element | 5333608.0517328177,2184682.2616140335,358.86789864030851 | -67.7257 | -0.0000255847 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.372Z | Extended Element | 5333607.2069242951,2184682.1515972684,358.8678996581553 | -67.7257 | -0.0000255513 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.398Z | Extended Element | 5333607.9267772306,2184681.9016867038,358.86789879491232 | -67.7257 | -0.0000255868 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.426Z | Extended Element | 5333607.0869945604,2184681.8061465942,358.8678998065115 | -67.7257 | -0.000025561 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.453Z | Extended Element | 5333607.806847496,2184681.5562360273,358.86789894402517 | -67.7257 | -0.0000256084 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.478Z | Extended Element | 5333606.9670648193,2184681.4606959154,358.8678999541425 | -67.7257 | -0.0000255674 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.505Z | Extended Element | 5333607.6869177576,2184681.210785348,358.86789909118846 | -67.7257 | -0.0000255965 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.529Z | Extended Element | 5333606.847135081,2184681.1152452421,358.86790010150315 | -67.7257 | -0.0000255825 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.558Z | Extended Element | 5333607.5669880174,2184680.8653346738,358.86789923910129 | -67.7257 | -0.0000256084 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.581Z | Extended Element | 5333606.7272053426,2184680.7697945628,358.86790025023612 | -67.7257 | -0.0000255868 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.608Z | Extended Element | 5333607.4470582772,2184680.5198839949,358.86789938719573 | -67.7257 | -0.0000255847 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.636Z | Extended Element | 5333607.3221027004,2184680.1599566652,358.86789954120184 | -67.7257 | -0.0000255868 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.662Z | Extended Element | 5333607.1971470611,2184679.8000293355,358.82344960641746 | -67.7257 | -0.0000255415 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.689Z | Extended Element | 5333606.3523385413,2184679.69001257,358.82345062295894 | -67.7257 | -0.0000255297 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.713Z | Extended Element | 5333607.0721914731,2184679.440102003,358.82344975951617 | -67.7257 | -0.0000255652 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.740Z | Extended Element | 5333606.2324088039,2184679.3445618921,358.82345077145857 | -67.7257 | -0.0000254963 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.765Z | Extended Element | 5333606.9522617348,2184679.0946513275,358.8234499081874 | -67.7257 | -0.0000255555 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.793Z | Extended Element | 5333606.1124790674,2184678.9991112174,358.82345091978829 | -67.7257 | -0.00002552 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.822Z | Extended Element | 5333605.9925493281,2184678.6536605386,358.82345106740496 | -67.7257 | -0.0000255652 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.847Z | Extended Element | 5333606.8323319992,2184678.7492006528,358.82345005603383 | -67.7257 | -0.0000255555 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.874Z | Extended Element | 5333606.7124022571,2184678.4037499754,358.82345020412475 | -67.7257 | -0.0000255965 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.901Z | Extended Element | 5333605.8726195917,2184678.308209864,358.82345121569284 | -67.7257 | -0.0000255652 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.929Z | Extended Element | 5333606.5924725188,2184678.0582992993,358.82345035214013 | -67.7257 | -0.0000255415 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.955Z | Extended Element | 5333606.4675169438,2184677.6983719687,358.82345050661689 | -67.7257 | -0.0000255652 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:28.981Z | Extended Element | 5333606.3485707538,2184677.3557543443,358.82345065352672 | -67.7257 | -0.0000255631 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.009Z | Extended Element | 5333605.5170606785,2184677.2840430452,358.80440161523416 | -67.7257 | -0.0000255297 | 89.9999 | -0.012700000000000003,0,-0.012700000232830652 | 0.012700000000000003,2.1336042672085465,0.012699999767169365
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.022Z | Extended Element | 5333610.0905002225,2184690.7130931034,359.79499423350751 | 0 | 0 | 0 | -1.4939194326046845e-10,4.3639758473545953e-11,-2.6090241078691179e-14 | 0.98265378039086682,0.49947564225675073,1.2262169591727996
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.050Z | Extended Element | 5333610.9783767145,2184691.1513282135,360.55064838875433 | 0.514424 | 89.9999 | 90.3402 | -0.012497246565172107,-1.8597985714131669e-11,-0.012497246803533842 | 0.01249724656505842,0.93460746318719079,0.83233821729842772
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.075Z | Extended Element | 5333610.9783763513,2184691.1513282103,360.24584777915226 | 0.51443 | 89.9999 | 90.3402 | -0.012497246565172107,-1.8597985714131669e-11,-0.012497246803533842 | 0.01249724656505842,0.93460746318719079,0.83233821729842772
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.089Z | Extended Element | 5333605.4181859605,2184676.7492140178,359.79500040918634 | 0 | 0 | 0 | -5.4675530769543457e-10,-9.7405139509731953e-12,-1.5543122344752192e-15 | 0.98024062993232719,0.49706178256986777,1.2402759967051367
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.117Z | Extended Element | 5333606.3103010291,2184676.821159136,360.55065209147904 | 0.514417 | -90.0001 | -90.3402 | -0.012497246598317946,-1.5540934307419288e-10,-0.012497246836736512 | 0.012497246598317946,0.79196130484472338,0.83233821730706048
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.146Z | Extended Element | 5333606.310300664,2184676.8211591323,360.24585148187771 | 0.514305 | -90.0001 | -90.3403 | -0.012497246598317946,-1.5540934307419288e-10,-0.012497246836736512 | 0.012497246598317946,0.79196130484472338,0.83233821730706048
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.163Z | Extended Element | 5333605.4169789515,2184677.2305543851,359.79499712172145 | 0 | 0 | 0 | -4.7397241687008318e-10,-3.4700375906027148e-10,-2.5091040356528538e-14 | 3.3158158067274934,6.758197749864129,1.3596203334934283
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.190Z | Extended Element | 5333605.5023403615,2184677.1243889756,360.14927485073594 | -19.0995 | 0.0458571 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.217Z | Extended Element | 5333606.3569261162,2184679.585973673,360.194313944106 | -19.0995 | 0.0458569 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.246Z | Extended Element | 5333607.2115118699,2184682.0475583719,360.23935251653853 | -19.0995 | 0.0458566 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.261Z | Extended Element | 5333607.757331755,2184683.9718236267,359.79499423334147 | 0 | 0 | 0 | -5.0350168478985324e-11,-2.6324808999333982e-10,2.708944180085382e-14 | 3.315822068009318,6.7581978421063749,1.3596232218735649
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.289Z | Extended Element | 5333608.0660975678,2184684.5091430689,360.23544532478513 | -19.0995 | 0.045857 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.317Z | Extended Element | 5333608.9206832051,2184686.9707277664,360.18259287393937 | -19.0995 | 0.0458566 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.344Z | Extended Element | 5333609.7752688415,2184689.4323124653,360.12973877120208 | -19.0995 | 0.0458566 | -45 | -0.0081589627744231754,1.0241366944666966e-10,-0.0081478903524337867 | 0.0081633231818934743,1.0504218640972089,1.0424958980821291
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.359Z | Extended Element | 5333608.7268903423,2184683.974021052,360.06110569625412 | 70.8546 | -1.0767 | 90.0001 | 5.4971940219532696e-10,-0.13408858968521187,-2.2934548591554242 | 7.2901914380255874,0.89855978606429265,2.6744548608332193
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.384Z | Extended Element | 5333610.2580531817,2184690.8627523775,360.63544325609053 | 70.8546 | -0.0000233305 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.414Z | Extended Element | 5333610.1622539107,2184690.5868080934,360.64093306916106 | 70.8546 | -0.0000233836 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.442Z | Extended Element | 5333610.0072064186,2184689.8606738346,360.6547809799165 | -109.149 | -88.9233 | -28.8943 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.469Z | Extended Element | 5333609.9123427598,2184689.8669534335,360.65525431994928 | 70.8546 | -0.0000234174 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.498Z | Extended Element | 5333609.7873871885,2184689.5070261001,360.6624149477779 | 70.8546 | -0.0000232701 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.527Z | Extended Element | 5333609.6674574586,2184689.1615754231,360.66928756627669 | 70.8546 | -0.0000235309 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.556Z | Extended Element | 5333609.4275979958,2184688.4706740677,360.68303280312631 | 70.8546 | -0.0000232967 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.583Z | Extended Element | 5333609.5475277267,2184688.8161247447,360.67616018439031 | 70.8546 | -0.0000232363 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.614Z | Extended Element | 5333609.307668265,2184688.1252233903,360.68990542057765 | 70.8546 | -0.0000235309 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.643Z | Extended Element | 5333609.1526207756,2184687.399089132,360.70375333510339 | -109.149 | -88.9233 | -28.8943 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.673Z | Extended Element | 5333609.0577571169,2184687.4053687281,360.70422667370781 | 70.8546 | -0.000023444 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.699Z | Extended Element | 5333608.9328015456,2184687.0454413998,360.71138729988763 | 70.8546 | -0.0000233571 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.722Z | Extended Element | 5333608.8128718147,2184686.6999907228,360.71825991882241 | 70.8546 | -0.0000233571 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.746Z | Extended Element | 5333608.6929420857,2184686.3545400472,360.7251325373548 | 70.8546 | -0.0000235647 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.771Z | Extended Element | 5333608.5730123548,2184686.0090893707,360.73200515584443 | 70.8546 | -0.0000232701 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.801Z | Extended Element | 5333608.4530826267,2184685.6636386947,360.73887777441041 | 70.8546 | -0.0000233305 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.829Z | Extended Element | 5333608.2980351346,2184684.9375044391,360.75272568698233 | -109.149 | -88.9233 | -28.8943 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.857Z | Extended Element | 5333608.2031714786,2184684.9437840348,360.75319902657503 | 70.8546 | -0.0000232967 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.884Z | Extended Element | 5333608.0782159036,2184684.5838567051,360.76035965192921 | 70.8546 | -0.0000233908 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.913Z | Extended Element | 5333609.1447722791,2184684.1950965272,360.76007120817741 | 70.8546 | -0.0000231358 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.941Z | Extended Element | 5333609.2697278522,2184684.5550238569,360.75291058282488 | 70.8546 | -0.0000229575 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.967Z | Extended Element | 5333609.3946834281,2184684.914951188,360.74574995616098 | 70.8546 | -0.0000233403 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:29.996Z | Extended Element | 5333609.5196390003,2184685.2748785177,360.73858933066043 | 70.8546 | -0.000023307 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.023Z | Extended Element | 5333609.6395687293,2184685.6203291928,360.73171671208991 | 70.8546 | -0.0000233332 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.050Z | Extended Element | 5333609.7594984611,2184685.9657798689,360.72484409360385 | 70.8546 | -0.0000230502 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.079Z | Extended Element | 5333609.999357922,2184686.6566812219,360.71109885613589 | 70.8546 | -0.0000233665 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.107Z | Extended Element | 5333609.8794281892,2184686.3112305445,360.71797147507147 | 70.8546 | -0.0000231953 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.134Z | Extended Element | 5333610.1243134933,2184687.0166085507,360.70393822995493 | 70.8546 | -0.0000231953 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.164Z | Extended Element | 5333610.2492690682,2184687.3765358813,360.69677760420467 | 70.8546 | -0.0000231097 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.192Z | Extended Element | 5333610.3742246395,2184687.7364632129,360.68961697682653 | 70.8546 | -0.000023162 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.218Z | Extended Element | 5333610.4941543704,2184688.0819138894,360.68274435937337 | 70.8546 | -0.0000232809 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.247Z | Extended Element | 5333610.6140841004,2184688.4273645668,360.67587174064124 | 70.8546 | -0.0000231882 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.275Z | Extended Element | 5333610.734013834,2184688.7728152457,360.66899912252757 | 70.8546 | -0.0000232214 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.300Z | Extended Element | 5333610.8539435621,2184689.1182659231,360.66212650402429 | 70.8546 | -0.0000230169 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.328Z | Extended Element | 5333610.9788991371,2184689.4781932556,360.65496587619754 | 70.8546 | -0.0000232476 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.358Z | Extended Element | 5333611.1038547093,2184689.8381205848,360.64780525027919 | 70.8546 | -0.000023307 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.382Z | Extended Element | 5333611.2288102843,2184690.198047915,360.64064462541182 | 70.8546 | -0.0000232214 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.411Z | Extended Element | 5333611.3246095581,2184690.4739922001,360.63515481233969 | 70.8546 | -0.0000232809 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.425Z | Extended Element | 5333606.3912261492,2184677.2462757993,359.94349088842887 | 70.8546 | 0.942099 | 90.0001 | 7.2091228993376166e-10,-0.11961207631553861,-2.2934548584602026 | 7.2881125720157538,0.87922976533258179,2.6744548615284378
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.451Z | Extended Element | 5333607.9582861913,2184684.2384061003,360.76189760512665 | 70.8546 | -0.0000234174 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.479Z | Extended Element | 5333607.8383564483,2184683.8929554252,360.75588434169657 | 70.8546 | -0.0000235044 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.505Z | Extended Element | 5333607.7184267007,2184683.5475047478,360.74987107849535 | 70.8546 | -0.0000233836 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.532Z | Extended Element | 5333607.5984969586,2184683.2020540694,360.74385781417698 | 70.8546 | -0.0000235044 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.560Z | Extended Element | 5333607.4434494516,2184682.475919812,360.74427984257045 | -109.149 | -88.9233 | -28.8943 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.586Z | Extended Element | 5333607.348585777,2184682.4821994086,360.73132729721891 | 70.8546 | -0.0000235044 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.613Z | Extended Element | 5333607.223630189,2184682.1222720775,360.72506203819313 | 70.8546 | -0.0000234778 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.642Z | Extended Element | 5333607.1037004432,2184681.7768214019,360.71904877487117 | 70.8546 | -0.0000232701 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.668Z | Extended Element | 5333606.9837706964,2184681.431370724,360.71303551196513 | 70.8546 | -0.0000233571 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.695Z | Extended Element | 5333606.8638409497,2184681.0859200489,360.70702224734248 | 70.8546 | -0.0000233039 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.723Z | Extended Element | 5333606.7439112104,2184680.7404692881,360.70100900844488 | 70.8546 | -0.0000233305 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.751Z | Extended Element | 5333606.5888636848,2184680.0143350386,360.70143103682994 | -109.149 | -88.9233 | -28.8943 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.779Z | Extended Element | 5333606.4939999925,2184680.0206146138,360.68847846367424 | 70.8546 | -0.0000232967 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.806Z | Extended Element | 5333606.3690444008,2184679.6606872845,360.68221320487999 | 70.8546 | -0.000023444 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.847Z | Extended Element | 5333606.249114655,2184679.3152366062,360.67619994107946 | 70.8546 | -0.0000234174 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.874Z | Extended Element | 5333606.1291849082,2184678.9697859301,360.67018667773374 | 70.8546 | -0.0000236251 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.900Z | Extended Element | 5333606.0092551634,2184678.624335255,360.66417341450455 | 70.8546 | -0.0000236517 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.928Z | Extended Element | 5333605.8893254278,2184678.2788846018,360.6581601514813 | 70.8546 | -0.000023444 | -180 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.950Z | Extended Element | 5333605.7342777289,2184677.55275041,360.6585821223855 | -109.149 | -88.9233 | -28.8943 | -0.011677719260260306,9.0674642023275143e-11,-0.0099799212905963986 | 0.2969598303120517,1.0975105434726873,0.20353964573729436
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:30.976Z | Extended Element | 5333605.6298653642,2184677.3228062605,360.64829244787643 | -89.1454 | 180 | 0.0000689403 | -0.011397382003998979,-4.1074041821852834e-10,-0.011397381479921044 | 0.011397381448346693,1.1464621507980484,0.29686309350637752
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.001Z | Extended Element | 5333606.759076748,2184677.3232388804,360.64800392460165 | 90.8546 | 3.92956e-07 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.031Z | Extended Element | 5333606.8309260011,2184677.5301971389,360.65160636522552 | 70.8546 | -0.0000231358 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.057Z | Extended Element | 5333606.9558818024,2184677.8901244239,360.65787170773041 | 70.8546 | -0.000023307 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.081Z | Extended Element | 5333607.075811537,2184678.2355750762,360.6638849707544 | 70.8546 | -0.0000230764 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.107Z | Extended Element | 5333607.1957412837,2184678.5810257532,360.66989823398461 | 70.8546 | -0.0000231358 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.133Z | Extended Element | 5333607.3156710295,2184678.9264764274,360.6759114973284 | 70.8546 | -0.000023162 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.162Z | Extended Element | 5333607.4356007753,2184679.2719271057,360.68192476112984 | 70.8546 | -0.0000229908 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.189Z | Extended Element | 5333607.560556368,2184679.6318544354,360.68819001992415 | 70.8546 | -0.0000232809 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.215Z | Extended Element | 5333607.6855119569,2184679.9917817651,360.69445527875934 | 70.8546 | -0.000023307 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.243Z | Extended Element | 5333607.8104675859,2184680.3517091097,360.70072056469292 | 70.8546 | -0.0000231358 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.269Z | Extended Element | 5333607.9303973252,2184680.6971598715,360.70673380359051 | 70.8546 | -0.000023162 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.299Z | Extended Element | 5333608.0503270701,2184681.0426105475,360.71274706821606 | 70.8546 | -0.0000232476 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.322Z | Extended Element | 5333608.1702568159,2184681.3880612236,360.7187603311192 | 70.8546 | -0.0000234259 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.349Z | Extended Element | 5333608.2901865598,2184681.7335119015,360.72477359444292 | 70.8546 | -0.0000231882 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.371Z | Extended Element | 5333608.4151421525,2184682.0934392302,360.73103885346785 | 70.8546 | -0.0000231358 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.396Z | Extended Element | 5333608.5400977405,2184682.4533665599,360.7373041122313 | 70.8546 | -0.000023162 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.421Z | Extended Element | 5333608.6650533313,2184682.8132938915,360.74356937042785 | 70.8546 | -0.0000229908 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.447Z | Extended Element | 5333608.7849830771,2184683.158744568,360.74958263474252 | 70.8546 | -0.0000232809 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:12:31.473Z | Extended Element | 5333608.9049128238,2184683.5041952478,360.75559589794648 | 70.8546 | -0.000023307 | -89.9999 | -0.010202642697827937,-6.0408171003277668e-19,-0.010202643002618358 | 0.010202642615987518,0.61186534359651046,0.60166369961667765
