Properties of the parts of a building model (IFC4X3_ADD2), part 15 of 39

# IfcBuildingElementProxy: <null> (7667)
Name | Description | [Generic].[Graphic3d], In Spatial Index | [Generic].[Graphic3d], Last Modified | [Generic].[Graphic3d], User Label | [Generic].[Graphic3d], Origin | [Generic].[Graphic3d], Yaw | [Generic].[Graphic3d], Pitch | [Generic].[Graphic3d], Roll | [Generic].[Graphic3d], Bounding Box Low | [Generic].[Graphic3d], Bounding Box High
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.268Z | Extended Element | 5333591.8040942568,2184687.8915926102,361.03050250739773 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.276Z | Extended Element | 5333591.9183817012,2184687.8932973789,361.0304020061543 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.287Z | Extended Element | 5333592.0326691475,2184687.8950021476,361.03030150492157 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.297Z | Extended Element | 5333592.1469565909,2184687.8967069164,361.03020100368144 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.306Z | Extended Element | 5333592.2612440372,2184687.8984116847,361.03010050243688 | 0.854589 | 0.0000219277 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.314Z | Extended Element | 5333592.3755314816,2184687.9001164534,361.03000000120204 | 0.854589 | 0.0000163807 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.322Z | Extended Element | 5333592.4898189278,2184687.9018212217,361.02989949993855 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.331Z | Extended Element | 5333592.6041063713,2184687.9035259895,361.02979899870661 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.340Z | Extended Element | 5333592.7183938175,2184687.9052307582,361.02969849746881 | 0.854589 | 0.0000295763 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.350Z | Extended Element | 5333592.8326812629,2184687.9069355261,361.02959799621323 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.358Z | Extended Element | 5333592.9469687091,2184687.9086402948,361.02949749497645 | 0.854589 | 0.0000295108 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.368Z | Extended Element | 5333593.0612561544,2184687.9103450631,361.02939699374747 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.376Z | Extended Element | 5333593.1755435979,2184687.9120498314,361.0292964924995 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.388Z | Extended Element | 5333593.2898310423,2184687.9137546001,361.0291959912625 | 0.854589 | 0.0000219276 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.397Z | Extended Element | 5333593.4041184885,2184687.9154593679,361.02909549002044 | 0.854589 | 0.0000230484 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.406Z | Extended Element | 5333593.5184059329,2184687.9171641357,361.02899498878406 | 0.854589 | 0.0000295683 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.417Z | Extended Element | 5333593.6326933783,2184687.918868904,361.02889448754524 | 0.854589 | 0.0000163807 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.424Z | Extended Element | 5333593.7469808236,2184687.9205736737,361.02879398628801 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.435Z | Extended Element | 5333593.8612682698,2184687.9222784415,361.02869348505686 | 0.854589 | 0.0000163232 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.444Z | Extended Element | 5333593.9755557133,2184687.9239832098,361.02859298381463 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.455Z | Extended Element | 5333594.0898431605,2184687.9256879771,361.02849248256962 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.465Z | Extended Element | 5333594.2041306049,2184687.9273927463,361.02839198131585 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.474Z | Extended Element | 5333594.318418052,2184687.9290975146,361.02829148008817 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.484Z | Extended Element | 5333594.4327054946,2184687.9308022833,361.02819097883173 | 0.854589 | 0.0000163807 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.493Z | Extended Element | 5333594.5469929408,2184687.9325070516,361.02809047759979 | 0.854589 | 0.0000218288 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.503Z | Extended Element | 5333594.6612803843,2184687.9342118199,361.02798997635762 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.513Z | Extended Element | 5333594.7755678305,2184687.9359165886,361.02788947510919 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.522Z | Extended Element | 5333594.8898552768,2184687.9376213565,361.02778897387947 | 0.854589 | 0.0000153666 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.532Z | Extended Element | 5333595.0041427221,2184687.9393261252,361.02768847262587 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.541Z | Extended Element | 5333595.1184301656,2184687.9410308935,361.02758797139296 | 0.854589 | 0.0000162739 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.551Z | Extended Element | 5333595.2327176109,2184687.9427356613,361.02748747014243 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.559Z | Extended Element | 5333595.3470050562,2184687.94444043,361.02738696891043 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.567Z | Extended Element | 5333595.4612925006,2184687.9461451978,361.02728646767451 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.576Z | Extended Element | 5333595.5755799469,2184687.9478499675,361.02718596641603 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.591Z | Extended Element | 5333595.6898672972,2184687.9495547335,361.02701868076213 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.600Z | Extended Element | 5333595.8041545618,2184687.9512594994,361.02679312010008 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.609Z | Extended Element | 5333595.9184418311,2184687.9529642658,361.02656755944224 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.619Z | Extended Element | 5333596.0327290948,2184687.9546690308,361.0263419987902 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.627Z | Extended Element | 5333596.1470163632,2184687.9563737977,361.02611643814384 | 0.854589 | 0.0000295108 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.636Z | Extended Element | 5333596.2613036288,2184687.9580785627,361.02589087746946 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.646Z | Extended Element | 5333596.3755908972,2184687.9597833282,361.02566531682709 | 0.854589 | 0.0000229084 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.654Z | Extended Element | 5333596.4898781646,2184687.9614880937,361.02543975617749 | 0.854589 | 0.0000163232 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.665Z | Extended Element | 5333596.6041654311,2184687.9631928597,361.02521419552636 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.673Z | Extended Element | 5333596.7184526967,2184687.9648976247,361.02498863488307 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.683Z | Extended Element | 5333596.8327399632,2184687.9666023906,361.02476307420721 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.692Z | Extended Element | 5333596.9470272316,2184687.968307157,361.02453751355779 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.703Z | Extended Element | 5333597.0613144971,2184687.9700119225,361.02431195290393 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.714Z | Extended Element | 5333597.1756017646,2184687.9717166875,361.02408639226149 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.723Z | Extended Element | 5333597.2898890311,2184687.973421454,361.02386083159854 | 0.854589 | 0.00001643 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.733Z | Extended Element | 5333597.4041762976,2184687.9751262199,361.0236352709436 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.741Z | Extended Element | 5333597.518463565,2184687.9768309854,361.02340971029344 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.753Z | Extended Element | 5333597.6327508325,2184687.9785357518,361.02318414963594 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.761Z | Extended Element | 5333597.7470380971,2184687.9802405168,361.02295858897423 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.771Z | Extended Element | 5333597.8613253646,2184687.9819452823,361.02273302832572 | 0.854589 | 0.000016438 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.780Z | Extended Element | 5333597.9756126301,2184687.9836500478,361.02250746768766 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.790Z | Extended Element | 5333598.0898998957,2184687.9853548133,361.02228190703221 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.800Z | Extended Element | 5333598.204187165,2184687.9870595802,361.02205634636874 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.809Z | Extended Element | 5333598.3184744315,2184687.9887643456,361.02183078572051 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.819Z | Extended Element | 5333598.4327616999,2184687.9904691107,361.02160522507108 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.831Z | Extended Element | 5333598.5470489673,2184687.9921738771,361.02137966442052 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.839Z | Extended Element | 5333598.661336232,2184687.9938786421,361.02115410376211 | 0.854589 | 0.0000231059 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.850Z | Extended Element | 5333598.7756234994,2184687.995583408,361.02092854311178 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.858Z | Extended Element | 5333598.889910765,2184687.9972881735,361.0207029824586 | 0.854589 | 0.0000218702 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.869Z | Extended Element | 5333599.0041980334,2184687.9989929395,361.02047742180451 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.878Z | Extended Element | 5333599.1184852989,2184688.000697705,361.02025186114315 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.888Z | Extended Element | 5333599.2327725664,2184688.0024024709,361.02002630050123 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.898Z | Extended Element | 5333599.3470598338,2184688.0041072364,361.01980073984396 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.906Z | Extended Element | 5333599.4613470994,2184688.0058120023,361.0195751791955 | 0.854589 | 0.0000163806 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.917Z | Extended Element | 5333599.575634365,2184688.0075167683,361.01934961853544 | 0.854589 | 0.0000163312 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.925Z | Extended Element | 5333599.6899216343,2184688.0092215338,361.01912405786948 | 0.854589 | 0.0000153092 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.936Z | Extended Element | 5333599.8042089008,2184688.0109262997,361.01889849723574 | 0.854589 | 0.0000218783 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.944Z | Extended Element | 5333599.9184961673,2184688.0126310652,361.01867293656784 | 0.854589 | 0.0000230484 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.956Z | Extended Element | 5333600.0327834338,2184688.0143358312,361.01844737593302 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.965Z | Extended Element | 5333600.1470707003,2184688.0160405966,361.01822181527291 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.976Z | Extended Element | 5333600.2613579659,2184688.0177453626,361.01799625460779 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.983Z | Extended Element | 5333600.3756452361,2184688.0194501276,361.01777069395922 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:40.992Z | Extended Element | 5333600.4899325017,2184688.0211548936,361.01754513330053 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.001Z | Extended Element | 5333600.6042197673,2184688.0228596595,361.01731957265662 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.010Z | Extended Element | 5333600.7185070328,2184688.0245644255,361.01709401199935 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.020Z | Extended Element | 5333600.8327943012,2184688.0262691905,361.01686845135379 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.030Z | Extended Element | 5333600.9470815677,2184688.0279739564,361.01664289068003 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.039Z | Extended Element | 5333601.0613688361,2184688.0296787219,361.01641733003595 | 0.854589 | 0.0000218863 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.050Z | Extended Element | 5333601.1756560998,2184688.0313834879,361.0161917693901 | 0.854589 | 0.0000152185 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.059Z | Extended Element | 5333601.2899433682,2184688.0330882533,361.01596620874267 | 0.854589 | 0.0000295108 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.070Z | Extended Element | 5333601.4042306356,2184688.0347930198,361.01574064808153 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.080Z | Extended Element | 5333601.5185179012,2184688.0364977848,361.01551508744012 | 0.854589 | 0.0000230072 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.089Z | Extended Element | 5333601.6328051677,2184688.0382025503,361.0152895267621 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.100Z | Extended Element | 5333601.747092437,2184688.0399073167,361.01506396611342 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.108Z | Extended Element | 5333601.8613797026,2184688.0416120822,361.01483840546649 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.120Z | Extended Element | 5333601.97566697,2184688.0433168481,361.0146128448186 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.130Z | Extended Element | 5333602.0899542347,2184688.0450216141,361.01438728415189 | 0.854589 | 0.0000153092 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.140Z | Extended Element | 5333602.2042415021,2184688.04672638,361.01416172350298 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.150Z | Extended Element | 5333602.3185287695,2184688.048431145,361.01393616286396 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.160Z | Extended Element | 5333602.4328160351,2184688.0501359105,361.01371060219736 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.170Z | Extended Element | 5333602.5471033044,2184688.0518406765,361.01348504154186 | 0.854589 | 0.0000163313 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.182Z | Extended Element | 5333602.6613905691,2184688.0535454424,361.01325948089931 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.191Z | Extended Element | 5333602.7756778374,2184688.0552502074,361.01303392022942 | 0.854589 | 0.0000218288 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.202Z | Extended Element | 5333602.889965103,2184688.0569549729,361.01280835959199 | 0.854589 | 0.0000295187 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.210Z | Extended Element | 5333603.0042523686,2184688.0586597389,361.01258279893835 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.222Z | Extended Element | 5333603.1185396351,2184688.0603645048,361.01235723827074 | 0.854589 | 0.0000230071 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.233Z | Extended Element | 5333603.2328269035,2184688.0620692703,361.01213167762228 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.242Z | Extended Element | 5333603.3471141709,2184688.0637740362,361.01190611698314 | 0.854589 | 0.0000218208 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.259Z | Extended Element | 5333603.461401144,2184688.0654787971,361.01156452198308 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.270Z | Extended Element | 5333603.5756880986,2184688.0671835584,361.01121485513158 | 0.854589 | 0.0000229084 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.278Z | Extended Element | 5333603.689975054,2184688.0688883197,361.01086518828976 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.289Z | Extended Element | 5333603.8042620085,2184688.0705930814,361.01051552144122 | 0.854589 | 0.0000295108 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.299Z | Extended Element | 5333603.918548963,2184688.0722978422,361.01016585459223 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.309Z | Extended Element | 5333604.0328359175,2184688.0740026021,361.00981618774352 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.319Z | Extended Element | 5333604.1471228721,2184688.0757073634,361.00946652088987 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.331Z | Extended Element | 5333604.2614098266,2184688.0774121252,361.00911685403628 | 0.854589 | 0.0000295763 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.339Z | Extended Element | 5333604.375696782,2184688.0791168869,361.00876718719684 | 0.854589 | 0.000022999 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.350Z | Extended Element | 5333604.4899837365,2184688.0808216473,361.00841752035848 | 0.854589 | 0.0000229004 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.359Z | Extended Element | 5333604.6042706911,2184688.0825264086,361.00806785350215 | 0.854589 | 0.0000162245 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.369Z | Extended Element | 5333604.7185576437,2184688.0842311685,361.0077181866493 | 0.854589 | 0.0000218863 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.378Z | Extended Element | 5333604.8328445982,2184688.0859359303,361.00736851980804 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.389Z | Extended Element | 5333604.9471315537,2184688.0876406915,361.00701885296576 | 0.854589 | 0.0000229003 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.399Z | Extended Element | 5333605.0614185082,2184688.0893454528,361.00666918611762 | 0.854589 | 0.0000163393 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.409Z | Extended Element | 5333605.1757054636,2184688.0910502137,361.00631951927789 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.419Z | Extended Element | 5333605.2899924181,2184688.0927549745,361.00596985241424 | 0.854589 | 0.0000228509 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.430Z | Extended Element | 5333605.4042793717,2184688.0944597353,361.00562018557673 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.439Z | Extended Element | 5333605.5185663253,2184688.0961644961,361.00527051871063 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.449Z | Extended Element | 5333605.6328532789,2184688.097869257,361.00492085187699 | 0.854589 | 0.0000219357 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.458Z | Extended Element | 5333605.7471402362,2184688.0995740187,361.00457118501998 | 0.854589 | 0.0000152104 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.468Z | Extended Element | 5333605.8614271916,2184688.101278781,361.00422151817151 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.476Z | Extended Element | 5333605.9757141452,2184688.1029835409,361.00387185133519 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.487Z | Extended Element | 5333606.0900010979,2184688.1046883017,361.00352218448802 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.497Z | Extended Element | 5333606.2042880543,2184688.106393063,361.00317251763289 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.506Z | Extended Element | 5333606.3185750078,2184688.1080978238,361.00282285079351 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.518Z | Extended Element | 5333606.4328619642,2184688.109802586,361.0024731839523 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.527Z | Extended Element | 5333606.5471489169,2184688.1115073469,361.00212351708922 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.537Z | Extended Element | 5333606.6614358714,2184688.1132121072,361.00177385025989 | 0.854589 | 0.0000152598 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.545Z | Extended Element | 5333606.775722825,2184688.1149168671,361.00142418341312 | 0.854589 | 0.0000295763 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.556Z | Extended Element | 5333606.8900097823,2184688.1166216293,361.00107451655805 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.566Z | Extended Element | 5333607.0042967349,2184688.1183263906,361.00072484969917 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.576Z | Extended Element | 5333607.1185836904,2184688.1200311515,361.00037518285382 | 0.854589 | 0.0000218783 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.584Z | Extended Element | 5333607.2328706449,2184688.1217359127,361.00002551601301 | 0.854589 | 0.0000152518 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.593Z | Extended Element | 5333607.3471575975,2184688.1234406736,360.99967584916516 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.602Z | Extended Element | 5333607.461444553,2184688.1251454344,360.99932618232225 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.612Z | Extended Element | 5333607.5757315075,2184688.1268501962,360.99897651546792 | 0.854589 | 0.00001643 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.623Z | Extended Element | 5333607.6900184629,2184688.1285549565,360.99862684863371 | 0.854589 | 0.0000295683 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.635Z | Extended Element | 5333607.8043054175,2184688.1302597183,360.99827718178051 | 0.854589 | 0.0000228923 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.644Z | Extended Element | 5333607.918592371,2184688.1319644786,360.99792751492686 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.656Z | Extended Element | 5333608.0328793256,2184688.1336692399,360.99757784808043 | 0.854589 | 0.0000152678 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.666Z | Extended Element | 5333608.147166281,2184688.1353740008,360.997228181244 | 0.854589 | 0.0000218782 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.676Z | Extended Element | 5333608.2614532346,2184688.1370787616,360.99687851439171 | 0.854589 | 0.0000296256 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.687Z | Extended Element | 5333608.375740191,2184688.1387835238,360.99652884752197 | 0.854589 | 0.0000229992 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.699Z | Extended Element | 5333608.4900271418,2184688.1404882837,360.996179180691 | 0.854589 | 0.0000162819 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.709Z | Extended Element | 5333608.6043140972,2184688.142193045,360.9958295138432 | 0.854589 | 0.0000153172 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.720Z | Extended Element | 5333608.7186010545,2184688.1438978063,360.99547984700621 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.728Z | Extended Element | 5333608.8328880072,2184688.1456025667,360.99513018015881 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.739Z | Extended Element | 5333608.9471749626,2184688.1473073289,360.99478051330073 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.749Z | Extended Element | 5333609.0614619162,2184688.1490120892,360.99443084645895 | 0.854589 | 0.0000229417 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.759Z | Extended Element | 5333609.1757488716,2184688.1507168505,360.99408117959234 | 0.854589 | 0.0000229578 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.769Z | Extended Element | 5333609.2900358252,2184688.1524216114,360.99373151276677 | 0.854589 | 0.0000295681 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.778Z | Extended Element | 5333609.4043227807,2184688.1541263713,360.99338184592102 | 0.854589 | 0.0000230565 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.789Z | Extended Element | 5333609.5186097352,2184688.1558311335,360.9930321790747 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.800Z | Extended Element | 5333609.6328966897,2184688.1575358943,360.99268251220917 | 0.854589 | 0.0000152024 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.810Z | Extended Element | 5333609.7471836442,2184688.1592406556,360.99233284536257 | 0.854589 | 0.0000229498 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.820Z | Extended Element | 5333609.8614705987,2184688.1609454164,360.99198317853495 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.829Z | Extended Element | 5333609.9757575523,2184688.1626501782,360.99163351167238 | 0.854589 | 0.0000229497 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.839Z | Extended Element | 5333610.0900445068,2184688.1643549381,360.99128384485101 | 0.854589 | 0.0000163887 | -1.14575 | -0.015009767808471894,1.2466391222946486e-10,-0.14141099039193514 | 0.015009710321915413,2.9790493103408915,0.021927954860110701
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.850Z | Line String | 5333610.1600080645,2184691.1375343506,360.94037607343483 | 0 | 0 | 0 | 0,-2.7429003668949008,-5.8314356010669144e-08 | 0.040914432145655155,0,0.046418199210847888
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.876Z | Extended Element | 5333610.2009224975,2184688.3946339837,360.98679427264119 | 0.854588 | -0.0000251341 | -1.14575 | -0.014347853094685125,-9.7219959705793419e-11,-0.1215127137779678 | 0.014347901848453816,2.7495508287665253,0.021456557715218174
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.886Z | Line String | 5333610.2742955806,2184691.1392391184,360.93997809599603 | 0 | 0 | 0 | 0,-2.4127364349551499,-5.8314299167250283e-08 | 0.035989545285701752,0,0.039814231622244733
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.911Z | Extended Element | 5333610.3102851268,2184688.7265026835,360.97979232760304 | 0.854588 | 0.00001128 | -1.14575 | -0.014347870709960976,-2.3642076109735297e-10,-0.12151275767917512 | 0.014347852926957503,2.4192841342629654,0.021456512016988699
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.923Z | Line String | 5333610.3885830967,2184691.1409438867,360.93957837355146 | 0 | 0 | 0 | 0,-2.1079697282984853,-5.8314299167250283e-08 | 0.031443498097360134,0,0.033718261521755721
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.947Z | Extended Element | 5333610.4200265957,2184689.0329741579,360.97329663507765 | 0.854588 | -0.00000289083 | -1.14575 | -0.014347852711963632,-1.0778020488401092e-10,-0.12151275881569472 | 0.014347857830016174,2.1144225710107967,0.021456511292081707
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.954Z | Line String | 5333610.5028706137,2184691.1426486545,360.93917683767245 | 0 | 0 | 0 | 0,-1.7778057958930731,-5.8314299167250283e-08 | 0.026518611237406731,0,0.027114293902627651
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.977Z | Extended Element | 5333610.5293892259,2184689.3648428582,360.96629113157491 | 0.854589 | 0.0000182562 | -1.14575 | -0.014347884444553299,-2.8343094516352843e-10,-0.12151275963104829 | 0.014347852887569556,1.7841558768650305,0.021456510535961298
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:41.990Z | Line String | 5333610.6171581289,2184691.1443534219,360.93877348891851 | 0 | 0 | 0 | 0,-1.4730390892364085,-5.8314356010669144e-08 | 0.021972564049065113,0,0.021018323801968108
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.016Z | Extended Element | 5333610.6391306939,2184689.6713143326,360.95979181272548 | 0.854588 | -0.0000295716 | -1.14575 | -0.014347852521044493,-3.9992229843366967e-10,-0.1215127624185621 | 0.014347916872382273,1.4792943130436458,0.021456508477665306
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.026Z | Line String | 5333610.7314456431,2184691.1460581906,360.938368326226 | 0 | 0 | 0 | 0,-1.1682723821140826,-5.8314299167250283e-08 | 0.01742651779204607,0,0.014922353701479096
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.052Z | Extended Element | 5333610.7488721618,2184689.9777858085,360.95329067993913 | 0.854589 | 0.00000688315 | -1.14576 | -0.014347876015358639,-2.2281604794174995e-10,-0.12151271253826544 | 0.014347852710266531,1.1744327504779031,0.021456557221344191
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.060Z | Line String | 5333610.8457331602,2184691.1477629589,360.93796135251409 | 0 | 0 | 0 | 0,-0.83810844970867038,-5.8314356010669144e-08 | 0.012501631863415241,0,0.0083183860822941824
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.089Z | Extended Element | 5333610.858234792,2184690.3096545096,360.94627973859644 | 0.854588 | -0.000023637 | -1.14576 | -0.014347850696282263,5.2172289174774716e-11,-0.12151270955210212 | 0.014347875077059933,0.84416605676614831,0.021456560469766343
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.101Z | Line String | 5333610.9600206753,2184691.1494677272,360.93755256677963 | 0 | 0 | 0 | 0,-0.53334174305200577,-5.8314356010669144e-08 | 0.0079555846750736237,0,0.0022224159818051703
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.125Z | Extended Element | 5333610.9622766105,2184690.9982291381,360.82325231729158 | 0.854588 | -0.00000523638 | 0.00000765319 | -0.014334897563160689,-0.38233610804778295,-0.01433489688627229 | 0.01433489982415972,0.15606532632081441,0.12863512628103288
Complex Chain | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.135Z | Complex Chain | 5333606.3975268519,2184676.8240469126,360.95312521032304 | 0 | 0 | 0 | -60.097718803212047,-0.89644746016710997,-0.074751603656523002 | 0,0,0.030204411423314703
Line String | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.142Z | Line String | 5333606.3975268528,2184676.8240469126,360.95312521032298 | 0 | 0 | 0 | -0.044323987327516079,0,0 | 0,2.9714746410027146,0.050990686012028164
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.168Z | Extended Element | 5333606.2475677477,2184679.7939458475,361.00442172871078 | -179.145 | -0.0000366921 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.186Z | Extended Element | 5333606.1332806516,2184679.7922410839,361.00472910267831 | -179.145 | -0.0000157654 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.196Z | Extended Element | 5333606.0189934578,2184679.7905363194,361.00499973436177 | -179.145 | -0.0000300817 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.206Z | Extended Element | 5333605.9047062621,2184679.7888315548,361.00527036606928 | -179.145 | -0.0000300738 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.216Z | Extended Element | 5333605.7904190673,2184679.7871267903,361.00554099776599 | -179.145 | -0.0000234554 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.225Z | Extended Element | 5333605.6761318725,2184679.7854220257,361.00581162946071 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.237Z | Extended Element | 5333605.5618446758,2184679.7837172602,361.00608226117379 | -179.145 | -0.000023398 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.245Z | Extended Element | 5333605.4475574847,2184679.7820124961,361.00635289285958 | -179.145 | -0.0000235126 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
Extended Element | [Generic].[Graphic3d] | yes | 2025-09-30T17:11:42.256Z | Extended Element | 5333605.3332702899,2184679.7803077316,361.00662352456516 | -179.145 | -0.0000300737 | -1.14576 | -0.014347855466798879,1.5693054712425032e-10,-0.12151271176839787 | 0.014347852738796733,2.9781969945810607,0.021456557800446169
